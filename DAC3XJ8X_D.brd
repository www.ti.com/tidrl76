# Allegro board DAC3XJ8X_D.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N17015106: length 7.2
  TOP w0.305: v1(83.82,53.34) 83.82,54.44 U5.36 ; v1(82.17,53.34) 82.35,53.52 U5.33 ; v2(86.36,65.02) 86.36,64.74 86.13,64.52 85.68,64.52 85.39,64.23 85.39,64.18 85.36,64.14 U5.10
  BOTTOM w0.254: 82.17,54.48 v1(82.17,53.34) v1(83.82,53.34)
  vias: v1(85.72,51.31) v1(85.72,50.55) v1(86.23,50.93)
N17015690: length 12
  TOP w0.254: U5.45 v2(88.36,53.88)
  BOTTOM w0.254: FB4.2 91.57,48.01 91.57,50.04 92.33,50.8 92.33,52.83 91,54.17 88.58,54.17 88.36,53.94 v2(88.36,53.88)
N17015695: length 2.6
  TOP w0.254: U5.39 v2(85.36,53.61)
  BOTTOM w0.254: 84.22,54.74 FB5.2
  BOTTOM w0.508: v2(85.36,53.61) 84.22,54.74
N17015811: length 1.7
  TOP w0.254: U5.17 81.21,62.81 v1(80.64,63.37)
  BOTTOM w0.254: FB6.2 80.39,63.63 v1(80.64,63.37)
  vias: v1(80.01,64.26) v1(80.64,64.01)
N17015820: length 3.9
  TOP w0.254: v1(79.12,60.58) 80.39,60.58 80.62,60.81 U5.21
  BOTTOM w0.508: FB8.2 78.87,60.83 v1(79.12,60.58)
  vias: v1(77.47,61.34) v1(77.72,60.33) v1(78.1,60.96)
N17015829: length 1.7
  TOP w0.254: U5.26 80.51,58.3 v1(80.26,58.55)
  BOTTOM w0.254: v1(80.26,58.55) 80.14,58.42 FB7.2
  vias: v1(79.25,58.42) v1(79.63,58.93)
N17015838: length 6.7
  TOP w0.254: U5.53 v1(91.67,57.3)
  BOTTOM w0.508: v1(91.67,57.3) 91.77,57.4 95.12,57.4 96.14,56.39 v1(96.9,56.39)
  vias: v1(96.52,56.9) v1(96.52,55.88)
N17015851: length 0.7
  TOP w0.254: U5.64 v1(90.69,63.49)
N17033325: length 1.5
  TOP w0.254: D8.1 R101.2
N17045898: length 1
  TOP w0.483: 94.87,41.22 R88.2
N17071256: length 41.1
  TOP w0.102: v2(119.51,92.2) 119.13,91.83 U2.M7 ; v1(124.21,87.38) 124.23,87.4 124.23,90.36 124.33,90.47 124.33,91.39 124.41,91.46 124.41,91.74 v2(124.21,91.95)
  TOP w0.152: v1(139.29,78.08) v1(139.29,87.38)
  BOTTOM w0.102: v1(139.29,87.38) 139.19,87.48 138.39,87.48 138.24,87.63 134.86,87.63 134.71,87.78 133.11,87.78 132.96,87.63 124.46,87.63 v1(124.21,87.38) ; v2(119.51,92.2) 119.63,92.2 119.84,92.41 123.37,92.41 123.42,92.35 123.49,92.35 123.89,91.95 v2(124.21,91.95)
  BOTTOM w0.152: J21.5 v1(139.29,78.08)
N17071268: length 40.8
  TOP w0.102: U2.M6 117.38,91.03 118.24,90.17 v2(118.49,90.17)
  TOP w0.152: v1(138.66,75.54) 138.66,87.86 v1(138.58,87.93)
  BOTTOM w0.102: v2(118.49,90.17) 120.89,90.17 120.97,90.25 121.35,90.25 121.65,89.94 122.1,89.94 122.38,89.66 125.27,89.66 125.32,89.71 125.89,89.71 125.94,89.66 127.25,89.66 127.38,89.53 127.38,88.39 127.84,87.93 132.94,87.93 133.01,88.01 134.8,88.01 134.88,87.93 v1(138.58,87.93)
  BOTTOM w0.152: J21.7 v1(138.66,75.54)
N17135362: length 1.4
  TOP w0.203: C198.1 84.84,50.42 R104.1
N17199056: length 15.3
  TOP w0.254: SW2.3 SW2.4 21.54,81.53 23.75,81.53 24,81.28 ; 24,81.28 24.26,81.53 R107.2 ; 24,81.28 C199.1 24.03,79.63 U15.2
N17199129: length 24.9
  TOP w0.152: U1.88 48.95,81.46 v1(48.64,81.15) ; v1(30.86,78.99) 27.5,78.99 U15.4
  BOTTOM w0.152: v1(48.64,81.15) 47.37,82.42 40.64,82.42 38.86,80.65 38.86,80.39 32.26,80.39 v1(30.86,78.99)
N17201332: length 3.8
  TOP w0.254: v1(35.06,46.63) 35.06,49.34 35.05,49.35 35.05,49.53 34.42,50.17
N17206708: length 16.3
  TOP w0.152: U1.16 58.14,91.85 59.69,90.3 59.69,88.65 62.1,86.23 62.1,82.68 J24.2
N17206717: length 14.3
  TOP w0.152: J24.4 62.61,84.71 62.61,86.61 60.07,89.15 60.07,90.55 58.27,92.35 U1.17
N17206727: length 12.6
  TOP w0.152: U1.18 58.79,92.85 60.71,90.93 60.71,89.15 J24.6
N17206729: length 11
  TOP w0.152: J24.8 62.23,90.17 62.23,90.68 59.56,93.35 U1.19
N17206761: length 9.8
  TOP w0.152: J24.10 64.13,90.81 62.61,90.81 59.57,93.85 U1.20
N17206763: length 9
  TOP w0.152: J24.12 61.85,92.58 60.08,94.35 U1.21
N17206775: length 11.2
  TOP w0.152: U1.26 v1(55.5,98.05)
  BOTTOM w0.152: v1(55.5,98.05) 58.67,98.05 61.59,95.12 J24.14
N17206777: length 12.7
  TOP w0.152: U1.27 v1(54.45,99.53)
  BOTTOM w0.152: v1(54.45,99.53) 58.71,99.53 60.58,97.66 J24.16
N17206789: length 15.8
  TOP w0.152: U1.28 v1(53.95,102.14)
  BOTTOM w0.152: J24.18 62.96,102.14 v1(53.95,102.14)
N17206791: length 16.2
  TOP w0.152: U1.29 v1(53.45,102.76)
  BOTTOM w0.152: v1(53.45,102.76) 64.88,102.76 J24.20
N17207204: length 16.9
  TOP w0.152: U1.89 49.45,81.28 48.81,80.65 45.85,80.65 45.59,80.39 37.53,80.39 J25.2
N17207206: length 15
  TOP w0.152: J25.4 39.71,80.04 45.87,80.04 46.1,80.26 49.18,80.26 49.95,81.03 U1.90
N17207236: length 13
  TOP w0.152: U1.91 50.45,80.9 49.43,79.88 46.48,79.88 46.36,79.76 41.97,79.76 J25.6
N17207238: length 11.1
  TOP w0.152: J25.8 44.13,79.38 46.74,79.38 46.96,79.6 49.55,79.6 49.57,79.63 49.91,79.63 50.95,80.66 U1.92
N17207240: length 10
  TOP w0.152: J25.10 46.16,78.87 47.12,78.87 47.57,79.32 49.66,79.32 49.69,79.35 50.03,79.35 50.05,79.38 50.93,79.38 52.45,80.89 U1.95
N17207242: length 8.1
  TOP w0.152: J25.12 48.88,79.04 49.78,79.04 49.8,79.07 51.38,79.07 52.95,80.63 U1.96
N17207244: length 6.1
  TOP w0.152: J25.14 51.05,78.11 53.45,80.5 U1.97
N17207246: length 4.9
  TOP w0.152: U1.98 53.95,80.11 53.09,79.25 53.09,78.17 J25.16
N17207248: length 5
  TOP w0.152: U1.99 54.45,80.43 55.56,79.31 J25.18
N17207250: length 5.9
  TOP w0.152: J25.20 56.39,79.82 56.39,79.88 54.95,81.32 U1.100
N17211055: length 2.1
  TOP w0.102: R1.1 24.97,111.69
  TOP w0.61: 24.97,111.69 U12.5
N17267622:
  vias: v1(17.65,108.97) v1(17.78,109.86) v1(18.29,108.71) v1(18.54,109.47) v1(18.92,108.84) v1(19.56,109.22) v1(19.68,108.59) v1(20.19,109.09)
N17273566: length 1.1
  TOP w0.102: R119.2 Q3.1
N17273570: length 1.1
  TOP w0.102: R120.2 Q4.1
N17273576: length 83.3
  TOP w0.102: 174.78,7.8 173.33,6.35 150.8,6.35 149.02,8.13 149.02,11.73 v2(149.86,12.57)
  TOP w0.152: 174.78,7.8 174.78,9.7 176.28,11.2 176.28,19.56 178.94,22.23 178.94,40.26 178.05,41.15 178.05,46.36 177.29,47.12 169.39,47.12 R120.1
N17273599: length 83.2
  TOP w0.102: 173.74,10.29 173.74,8.03 172.82,7.11 151.41,7.11 150.32,8.2 150.32,11.76 v2(151.13,12.57)
  TOP w0.152: R119.1 168.12,53.44 166.88,52.2 166.88,45.21 168.91,43.18 173.35,43.18 177.16,39.37 177.16,23.11 175.64,21.59 175.64,15.09 175.64,12.19 173.74,10.29
N17274139: length 1.1
  TOP w0.102: Q3.3 R127.2
N17274205: length 1.1
  TOP w0.102: 170.81,49.78 R121.2
N17277740: length 1.7
  TOP w0.102: R127.1 D2.2
N17277758: length 1.7
  TOP w0.102: R126.1 D3.2
N17277849: length 1.7
  TOP w0.102: R128.1 D11.2
N17292342: length 0.4
  BOTTOM w0.102: v1(76.24,117.35) 76.48,117.11 R71.1
N17293168: length 0.4
  BOTTOM w0.102: R184.2 v1(98.68,125.86)
N17293265: length 0.4
  BOTTOM w0.102: v1(149.49,117.35) 149.48,117.35 R72.2
N17316333: length 12.9
  TOP w0.483: 87.6,43.46 86.99,44.07 v1(83.44,44.07)
  TOP w0.508: R186.1 89.36,40.2 87.6,41.96 87.6,43.46
N17352995: length 1.6
  TOP w0.508: v2(110.82,91.83) v2(110.82,91.03)
  BOTTOM w0.508: v2(110.82,91.83) v2(110.82,91.03)
N17375290: length 1.4
  TOP w0.483: v1(69.97,123.61) T2.2
N17375633: length 8.4
  TOP w0.483: 82.95,112.81 82.95,112.84 R196.1 81.78,114.01 81.75,114.01 81.75,115.43 T1.6
N17385404: length 1.4
  TOP w0.483: T4.2 v1(98.71,134.75)
N17385560: length 8.4
  TOP w0.483: T3.4 96.17,120.64 97.2,119.62 R198.1 R25.2
N17385723: length 1.4
  TOP w0.483: v1(127.04,134.75) T6.2
N17386229: length 0.4
  BOTTOM w0.483: v1(127.04,125.89) 127,125.85 R183.1
N17386239: length 8.4
  TOP w0.483: T5.6 129.58,120.64 128.57,119.63 R200.1 R38.2
N17386557: length 1.4
  TOP w0.483: T8.2 v1(155.76,123.61)
N17386789: length 8.4
  TOP w0.483: T7.4 143.99,115.44 143.99,113.98 R202.1 143.56,113.56 R47.2
N17392271: length 8.4
  TOP w0.483: R5.2 80.79,110.67 R195.2 79.49,111.96 78.03,111.96 T1.4
N17393143: length 8.4
  TOP w0.483: T3.6 101.25,120.71 100.24,119.7 100.24,119 R197.2 100.24,119 R21.2
N17394079: length 8.4
  TOP w0.483: R33.2 R199.2 125.52,119.64 124.5,120.66 T5.4
N17395163: length 8.4
  TOP w0.483: R46.2 R201.2 146.15,111.84 147.57,111.84 T7.6
N18118787: length 2.2
  BOTTOM w0.305: C106.1 13.28,64.91 U6.14
N18138734: length 2.1
  TOP w0.152: D6.1 R85.1
N18138778: length 2.1
  TOP w0.203: R82.1 D5.1
N18138841: length 2.1
  TOP w0.203: D7.1 R86.1
N18138859: length 53.1
  TOP w0.203: U5.48 89.86,53.7 89.89,53.67 89.89,52.93 v2(89.66,52.71)
  BOTTOM w0.203: v1(42.67,45.72) 44.2,47.24 54.36,47.24 57.53,50.42 57.53,51.44 58.42,52.32 72.39,52.32 72.52,52.2 80.26,52.2 80.8,51.66 80.92,51.66 81.15,51.44 84.58,51.44 84.96,51.82 87.76,51.82 88.39,52.45 89.41,52.45 v2(89.66,52.71)
N18139187: length 58.1
  TOP w0.102: v1(79.12,52.83) 80.52,54.23 80.52,55.37 80.95,55.8 U5.31
  TOP w0.152: 42.77,36.83 43.56,37.62 43.56,42.67 41.66,44.58 v1(41.66,51.44)
  BOTTOM w0.203: v1(79.12,52.83) 57.02,52.83 55.63,51.44 v1(41.66,51.44)
N18494750: length 2.2
  BOTTOM w0.305: U6.11 13.96,62.96 R91.2
N18494760: length 2
  BOTTOM w0.305: U6.12 R90.2
N18496347: length 1.8
  BOTTOM w0.305: U6.10 R92.2
N18497261: length 1.8
  BOTTOM w0.305: U6.8 R93.2
N18499997: length 2.2
  BOTTOM w0.305: U8.14 155.94,72.97 C116.1
N18501914: length 1.8
  BOTTOM w0.381: U8.8 R97.2
N18501918: length 2.2
  BOTTOM w0.305: U8.11 157.89,73.65 R95.2
N18501920: length 2
  BOTTOM w0.305: U8.12 R94.2
N18501930: length 1.8
  BOTTOM w0.381: U8.10 R96.2
N18529139: length 80.3
  TOP w0.102: 174.19,7.85 173.08,6.73 151.03,6.73 149.38,8.38 149.38,10.82 v2(149.86,11.3)
  TOP w0.152: R121.1 167.26,48.79 167.26,45.34 168.78,43.82 174.12,43.82 177.8,40.13 177.8,22.1 175.92,20.22 175.92,15.21 175.92,14.98 175.92,11.58 174.19,9.86 174.19,7.85
N18582117: length 2
  TOP w0.152: v1(84.58,64.52) 84.45,64.52 84.35,64.42 U5.12
  BOTTOM w0.254: C88.1 84.45,64.39 v1(84.58,64.52)
N18582124: length 1.7
  TOP w0.152: U5.11 84.86,64.14 85.04,64.33 85.04,64.59 v2(85.34,64.9)
  BOTTOM w0.254: C87.1 v2(85.34,64.9)
N18582340: length 2.1
  TOP w0.203: R81.1 D4.1
N18582465: length 70.9
  TOP w0.152: U5.59 v1(91.8,60.31)
  TOP w0.203: v1(41.15,58.55) 41.15,42.9 R82.2
  BOTTOM w0.152: v1(41.15,58.55) 68.2,58.55 69.72,60.07 73.41,60.07 73.66,59.82 80.25,59.82 80.51,60.07 82.17,60.07 82.68,60.58 89.53,60.58 89.81,60.31 v1(91.8,60.31)
N18582474: length 59.6
  TOP w0.152: R81.2 42.8,50.19 v1(42.8,57.66) ; U5.58 v1(92.33,59.82)
  BOTTOM w0.152: v1(92.33,59.82) 89.9,59.81 89.66,59.56 80.39,59.56 80.37,59.54 73.54,59.54 73.52,59.56 70.48,59.56 68.58,57.66 v1(42.8,57.66)
N63034531: length 1.1
  TOP w0.152: R66.1 C61.2
N63036851: length 1.1
  TOP w0.152: C62.2 R65.1
N169575690: length 3.1
  BOTTOM w0.254: C133.1 177.99,92.01 U11.15
N170006640: length 3.3
  BOTTOM w0.254: C136.1 178.12,77.28 U9.15
N172735392: length 1.1
  TOP w0.102: Q4.3 R128.2
N172741842: length 1.1
  TOP w0.102: R126.2 Q2.3

## Copper pours and planes (outline as drawn)
1.8V_CPLD on L3_PWR: 60.07,94.62 55.5,94.62 55.5,87.38 55.37,87.25 53.47,87.25 51.82,88.9 45.97,88.9 45.97,92.71 44.83,93.85 41.53,93.85 41.53,90.81 43.43,90.81 43.43,88.9 39.5,88.9 39.5,97.16 39.62,97.28 46.1,97.28 46.23,97.41 52.58,97.41 52.58,114.81 46.23,114.81 46.23,103.51 40.64,103.51 40.64,108.84 42.93,111.12 42.93,116.97 59.94,116.97 63.5,113.41 63.5,96.52 62.87,95.89 60.07,95.89
1.8V_USB on TOP, L6_PWR: 30.99,100.97 30.99,98.93 35.94,98.93 35.94,100.97
1.8V_USB on BOTTOM: 30.86,100.97 30.86,98.93 35.94,98.93 35.94,100.97
1.8V_USB on L3_PWR: 36.7,88.9 32.13,88.9 32.13,92.08 22.86,92.08 22.86,98.93 24.26,98.93 24.26,94.23 32.26,94.23 32.26,96.27 30.61,97.92 30.61,100.2 31.88,101.47 35.69,101.47 35.69,106.81 37.08,108.2 39.37,108.2 40.26,107.31 40.26,100.08 36.7,96.52
3.3V on BOTTOM, L3_PWR, L6_PWR: 21.46,63.88 20.07,63.88 20.07,66.29 19.18,66.29 19.18,67.69 21.34,69.85 24.51,69.85 24.51,66.8 23.88,66.8 23.88,59.69 21.46,59.69
3.3V_CPLD on L3_PWR: 25.53,86.11 43.81,86.11 43.81,91.31 41.91,91.31 41.91,93.22 44.45,93.22 45.59,92.08 45.59,86.11 52.45,86.11 52.45,83.19 48.64,83.19 48.64,81.53 31.75,81.53 30.1,79.88 29.84,79.88 26.8,76.84 10.67,76.84 10.67,79.5 15.11,79.5 15.11,80.52 25.53,80.52
3.3V_USB on TOP: 24.38,113.54 24.38,117.09 29.72,117.09 29.72,111.25 26.16,111.25 26.16,113.54
3.3V_USB on TOP: 6.73,88.52 6.73,85.98 9.52,85.98 9.52,88.52
3.3V_USB on TOP: 9.78,88.65 9.78,90.17 12.32,90.17 12.32,88.65
3.3V_USB on L3_PWR: 6.35,119 29.72,119 29.72,112.27 32,109.98 32,102.49 30.1,100.58 30.1,97.54 31.62,96.01 31.62,94.74 28.7,94.74 25.91,97.54 25.91,100.58 22.61,100.58 22.61,91.06 31.37,91.06 31.37,88.65 20.57,88.65 20.57,113.28 8.76,113.28 8.64,113.16 8.64,107.82 16.76,107.82 16.76,105.03 11.94,105.03 9.52,102.62 9.52,90.17 12.19,90.17 12.19,88.52 9.78,88.52 9.78,86.11 11.18,86.11 11.18,85.09 12.95,83.31 14.54,83.31 14.54,79.95 14.48,79.88 6.22,79.88 6.1,80.01 5.33,80.01 3.81,81.53 3.81,116.46
+0.9V_DAC on BOTTOM: 163.19,75.69 163.19,88.27 171.83,88.27 171.83,80.26 174.88,80.26 175.64,79.5 175.64,77.22 174.5,76.07 169.8,76.07 169.8,80.65 166.12,80.65 166.12,75.95 165.99,75.95 165.99,75.69
+0.9V_DAC on BOTTOM: 117.09,82.04 117.09,80.01 118.11,80.01 118.11,82.04
+0.9V_DAC on L3_PWR: 169.8,76.07 169.8,77.09 163.19,77.09 163.19,88.27 171.83,88.27 171.83,80.26 175.26,80.26 175.26,76.07
+0.9V_DAC on L6_PWR: 163.19,75.69 163.19,89.15 166.62,89.15 166.62,107.82 99.34,107.82 99.34,89.64 97.38,89.64 97.38,81.28 117.22,81.28 117.22,82.04 118.24,82.04 118.24,79.63 91.57,79.63 91.57,109.47 170.18,109.47 170.18,84.84 167.51,84.84 167.51,75.69
+0.9V_VDDCLK on L3_PWR: 109.6,92.18 109.6,93.22 108.18,93.22 108.18,95.1 99.87,95.1 99.87,92.18
+0.9V_VDDDAC on L3_PWR: 110.62,93.73 110.74,93.73 111.12,94.11 114.55,94.11 114.93,93.73 115.95,93.73 116.78,94.55 117.41,94.55 120.01,97.16 120.01,101.85 129.29,101.85 129.29,97.54 128.4,96.65 124.97,96.65 124.21,95.89 124.21,93.09 123.32,92.2 117.47,92.2 117.22,91.95 110.74,91.95 110.62,92.08
+0.9V_VDDDIG on BOTTOM: 118.24,85.34 119,85.34 119,87.88 117.35,87.88 117.35,86.87 117.47,86.87 118.24,86.11
+0.9V_VDDDIG on BOTTOM: 160.02,64.52 162.56,64.52 162.56,67.28 159.72,67.28 158.55,68.45 155.7,68.45 155.57,68.33 155.57,64.14 159.64,64.14
+0.9V_VDDDIG on L3_PWR: 120.65,82.63 120.19,83.08 118.24,83.08 117.88,83.44 117.88,87.55 125.6,87.55 128.14,85.01 128.14,69.6 162.94,69.6 162.94,67.56 163.07,67.56 163.07,64.64 120.65,64.64
+0.9V_VDDDIG on L6_PWR: 111.38,89.1 111.38,88.93 111.43,88.87 111.51,88.87 111.51,88.14 110.36,88.14 110.36,90.42 111.25,90.42 111.25,89.92 114.43,89.92 114.43,90.81 114.3,90.93 114.3,92.33 115.19,92.33 115.19,90.93 115.82,90.3 115.95,90.3 116.08,90.42 117.98,90.42 118.11,90.3 118.11,88.87 118.92,88.06 122.3,88.06 122.83,87.53 122.83,83.46 122.38,83.01 118.34,83.01 118.11,83.24 118.11,85.93 115.7,85.93 115.7,87.76 114.35,89.1
+0.9V_VDDDIG on L6_PWR: 160.02,64.52 162.56,64.52 162.56,66.93 159.89,66.93 159.89,67.95 159.38,68.45 155.7,68.45 155.57,68.33 155.57,64.14 159,64.14 159,64.26 159.77,64.26
+0.9V_VDDT on BOTTOM: 118.74,82.8 119.89,82.8 119.89,79.38 118.62,79.38 118.49,79.5 118.49,82.55
+0.9V_VDDT on L3_PWR: 111.76,88.9 111.76,88.14 113.28,88.14 113.54,87.88 113.54,87.38 114.93,85.98 114.93,85.34 113.79,84.2 113.79,79.25 115.7,77.34 119.89,77.34 119.89,82.04 119.76,82.17 116.84,82.17 116.84,88.9
+1.8V_DAC on BOTTOM: 163.19,90.3 163.19,103.38 171.7,103.38 171.7,94.87 174.75,94.87 175.51,94.11 175.51,91.82 174.37,90.68 169.67,90.68 169.67,95.25 165.61,95.25 165.61,90.3
+1.8V_DAC on L3_PWR: 94.18,90.2 94.16,90.2 94.16,120.29 128.37,120.29 128.37,107.21 140.97,107.21 140.97,107.19 171.7,107.19 171.7,94.87 175.39,94.87 175.39,90.3 163.07,90.3 163.07,99.31 162.56,99.31 162.56,102.49 135.13,102.49 135.13,95.12 131.19,91.19 125.48,91.19 125.48,93.6 125.35,93.73 125.35,95.25 126.11,96.01 129.03,96.01 130.94,97.92 130.94,103.2 120.07,103.2 120.07,113.92 110.72,113.92 110.72,109.02 106.81,109.02 106.81,96.9 98.96,96.9 98.96,91.85 106.12,91.85 106.12,86.23 101.83,86.23 101.83,89.94 94.18,89.94
+1.8V_DAC on L6_PWR: 97.97,82.04 97.97,87.12 97.92,87.12 97.92,87.88 104.9,87.88 104.9,82.04
+1.8V_VDDAPLL on L6_PWR: 106.32,99.8 109.85,96.27 109.85,92.96 99.92,92.96 99.92,99.8
+1.8V_VDDAREF on L3_PWR: 119.13,97.66 116.97,95.5 116.97,95.12 115.82,93.98 115.06,93.98 115.06,94.49 114.05,94.49 114.05,96.27 111.25,96.27 110.49,95.5 110.49,93.85 108.58,93.85 108.58,108.08 111.43,108.08 111.43,113.03 119.13,113.03
+1.8V_VDDIO on L6_PWR: 80.07,100.9 77.85,103.12 42.29,103.12 42.29,110.11 77.09,110.11 78.74,108.46 88.01,108.46 88.01,78.11 121.41,78.11 123.44,80.14 123.44,90.42 120.01,90.42 120.01,90.3 118.36,90.3 118.11,90.55 115.7,90.55 115.32,90.93 115.32,92.33 116.46,93.47 120.65,93.47 120.9,93.73 126.49,93.73 128.14,92.08 137.16,92.08 137.67,91.57 149.22,91.57 149.22,93.6 149.48,93.85 149.48,99.44 156.84,99.44 156.84,89.03 149.61,89.03 149.61,87.25 148.46,87.25 148.46,89.03 127.38,89.03 127.38,78.99 126.49,78.11 126.49,74.42 125.09,73.03 81.34,73.03 80.07,74.3
+1.8V_VDDR on L3_PWR: 101.47,85.47 107.95,85.47 110.11,87.63 111.89,87.63 111.89,88.01 113.28,88.01 113.41,87.88 113.41,87 114.68,85.72 114.68,85.6 114.55,85.47 112.85,85.47 112.85,82.42 97.56,82.42 97.56,89.41 101.47,89.41
+1.8V_VDDS on BOTTOM: 105.92,83.82 107.31,83.82 107.31,86.11 107.19,86.11 107.19,88.77 105.28,88.77 105.28,86.87 105.92,86.23
+1.8V_VDDS on L6_PWR: 106.93,87.88 106.93,91.69 107.57,92.33 111.63,92.33 111.63,90.81 111.51,90.68 109.73,90.68 109.73,85.6 107.95,85.6 107.95,83.82 105.79,83.82 105.79,85.09 105.28,85.6 105.28,87.63 105.54,87.88
+2.5V_LDO_IN on BOTTOM: 172.08,101.09 172.08,97.66 175.64,97.66 175.64,101.09
+2.5V_LDO_IN on BOTTOM: 172.08,86.36 172.08,83.44 175.77,83.44 175.77,86.36
+2.5V_LDO_IN on BOTTOM: 177.8,82.55 177.8,84.07 179.58,84.07 179.58,82.55
+2.5V_LDO_IN on BOTTOM: 175.89,56.9 177.93,56.9 177.93,63.37 179.07,63.37 179.07,67.44 174.12,67.44 174.12,63.37 175.89,63.37
+2.5V_LDO_IN on BOTTOM: 177.55,97.03 177.55,98.55 179.32,98.55 179.32,97.03
+2.5V_LDO_IN on L3_PWR: 175.89,56.9 175.89,63.25 174.12,63.25 174.12,67.44 177.04,67.44 177.04,83.44 173.61,83.44 173.61,82.55 172.34,82.55 172.34,86.49 177.04,86.49 177.04,96.77 172.08,96.77 172.08,101.09 180.34,101.09 180.34,56.9
+3.3V_DAC on BOTTOM, L3_PWR: 159.13,85.09 161.29,85.09 161.29,94.62 162.43,94.62 162.43,98.55 157.48,98.55 157.48,94.62 159.13,94.62
+3.3V_DAC on BOTTOM, L3_PWR: 156.97,81.15 156.97,79.76 154.56,79.76 154.56,78.87 153.16,78.87 151,81.03 151,81.15 149.22,81.15 149.22,84.07 149.35,84.2 154.05,84.2 154.05,83.57 161.16,83.57 161.16,81.15
+3.3V_DAC on L6_PWR: 157.73,74.8 157.73,101.65 127.91,101.65 127.91,106.55 163.45,106.55 163.45,98.3 163.32,98.3 163.45,98.17 163.45,91.57 161.67,91.57 161.67,74.17 173.61,74.17 173.61,101.85 179.45,101.85 179.45,71.5 163.58,71.5 163.19,71.88 157.99,71.88 157.99,74.8
+3.3V_VDDADAC on L6_PWR: 110.36,93.85 110.36,106.55 127.15,106.55 127.15,101.98 115.95,101.98 115.95,96.9 115.7,96.65 115.32,96.65 115.32,94.11 115.06,93.85
+3.3VCLK on TOP: 27.3,111 27.3,108.71 29.72,108.71 29.72,111
+3.3VCLK on BOTTOM: 100.08,54.36 100.08,57.28 101.22,57.28 101.22,54.36
+3.3VCLK on BOTTOM: 25.4,61.72 25.4,59.56 31.24,59.56 32.13,58.67 40.39,58.67 40.39,63.12 40.13,63.37 35.81,63.37 34.16,61.72
+3.3VCLK on BOTTOM: 88.9,67.31 88.9,65.91 91.57,65.91 91.57,67.31
+3.3VCLK on BOTTOM: 76.58,59.18 76.58,55.5 77.98,55.5 77.98,59.18
+3.3VCLK on BOTTOM: 76.58,66.04 76.58,63.12 77.98,63.12 77.98,66.04
+3.3VCLK on L3_PWR: 95,36.83 95,40.01 97.54,40.01 97.54,47.24 87.38,47.24 87.38,45.47 87.25,45.34 85.85,45.34 85.72,45.47 85.72,46.61 84.96,47.37 84.96,48.64 85.22,48.9 87.25,48.9 87.76,48.39 91.19,48.39 91.19,50.17 97.54,50.17 97.54,64.26 89.92,64.26 89.92,66.8 89.79,66.93 78.61,66.93 78.61,64.39 78.74,64.26 78.74,54.86 72.52,54.86 72.52,58.8 26.16,58.8 25.4,59.56 25.4,61.72 26.04,62.36 27.3,62.36 27.3,70.49 10.79,70.49 10.79,76.58 15.11,76.58 15.11,73.66 34.29,73.66 34.29,66.42 36.7,64.01 72.52,64.01 72.52,70.61 101.98,70.61 102.23,70.36 102.23,69.72 102.36,69.6 102.36,68.45 102.23,68.33 102.23,41.66 118.62,41.66 118.62,39.75 102.23,39.75 102.23,36.83
+3.3VCLK on L6_PWR: 26.8,76.71 26.8,61.85 25.27,61.85 25.27,59.44 31.37,59.44 32.13,58.67 40.39,58.67 40.39,63.88 33.15,63.88 33.15,98.68 30.61,98.68 30.61,101.35 33.15,101.35 33.15,112.01 25.15,112.01 25.15,105.16 24.64,104.65 24.64,78.87
+5.0V on TOP: 172.21,67.69 172.21,68.33 168.91,68.33 168.91,75.18 171.32,75.18 171.32,71.88 174.88,71.88 174.88,67.69
+5.0V on BOTTOM: 15.75,65.53 15.75,68.96 12.45,68.96 12.45,65.53
+5.0V on BOTTOM: 174.88,68.07 174.88,71.88 171.32,71.88 171.32,75.18 168.78,75.18 168.91,75.06 168.91,68.33 168.78,68.2 168.78,66.93 173.74,66.93
+5.0V on BOTTOM: 152.27,72.39 155.07,72.39 155.07,76.58 152.27,76.58
+5.0V on BOTTOM, L6_PWR: 12.7,65.79 12.7,68.83 17.02,68.83 17.02,65.79
+5.0V on BOTTOM, L6_PWR: 38.24,43.31 38.24,45.47 28.97,45.47 28.97,43.31
+5.0V on L3_PWR: 1.78,33.4 1.78,66.55 12.7,66.55 12.7,68.83 17.02,68.83 17.02,62.1 5.59,62.1 5.59,44.07 12.95,36.7 28.96,36.7 28.96,43.43 28.97,43.43 28.97,45.47 38.24,45.47 38.24,43.43 77.47,43.43 84.58,36.32 120.78,36.32 120.78,6.73 121.03,6.48 171.2,6.48 173.23,8.51 173.23,22.35 168.34,27.24 168.34,57.47 169.93,59.06 169.93,69.72 169.29,70.36 169.29,73.28 167.39,73.28 165.73,74.93 164.21,74.93 163.51,74.23 163.51,73.22 161.16,70.87 154.81,70.87 154.81,72.01 152.27,72.01 151.76,72.52 151.76,76.71 151.89,76.84 152.53,76.84 153.8,75.56 156.21,75.56 157.23,74.55 160.78,74.55 162.69,76.45 169.04,76.45 169.67,75.82 170.43,75.82 174.5,71.75 174.5,67.69 173.35,67.69 173.35,59.18 178.44,54.1 178.94,54.1 179.7,53.34 179.7,44.83 178.44,43.56 178.44,4.95 175.64,2.16 114.68,2.16 114.68,33.27 114.55,33.4
+5.0V on L6_PWR: 1.78,33.4 1.78,67.82 5.21,71.25 17.02,71.25 17.02,66.17 16.89,66.04 12.45,66.04 12.32,66.17 12.32,67.95 10.03,67.95 9.91,67.82 9.91,62.1 5.59,62.1 5.59,44.07 12.95,36.7 28.96,36.7 28.96,43.43 28.97,43.43 28.97,45.47 38.24,45.47 38.24,43.43 40.26,43.43 41.27,44.45 168.34,44.45 168.34,57.4 167.39,58.36 167.39,64.39 162.56,69.22 153.03,69.22 151.76,70.49 151.76,76.71 152.02,76.96 153.67,76.96 156.08,74.55 157.35,74.55 157.35,70.99 165.1,70.99 165.35,70.74 171.07,70.74 171.32,70.99 176.91,70.99 176.91,61.59 178.44,60.07 178.44,33.27 114.68,33.27 114.55,33.4
+5V_IN on BOTTOM: 17.67,50.29 18.8,50.29 18.8,47.24 23,47.24 23.13,47.12 23.13,46.48 23.51,46.48 23.51,42.67 21.22,42.67 21.22,37.47 16.78,37.47 16.78,42.67 10.17,42.67 10.17,51.56 10.93,52.32 15.63,52.32
+5V_IN on L3_PWR: 15.11,37.34 15.11,42.42 9.27,42.42 9.27,52.83 18.67,52.83 18.67,47.12 23.62,47.12 23.75,47.24 23.75,42.42 22.1,42.42 22.1,37.34
+5V_IN on L6_PWR: 17.67,50.29 18.67,50.29 18.67,47.37 23.13,47.37 23.13,46.48 23.51,46.48 23.51,42.67 21.22,42.67 21.22,37.47 16.78,37.47 16.78,42.67 10.17,42.67 10.17,51.56 10.93,52.32 15.63,52.32
+5V_USB on TOP: 13.34,110.62 13.34,110.68 9.21,110.68 9.21,112.59 13.4,112.59 13.84,113.03 20.7,113.03 20.7,111.38 18.67,111.38 17.91,110.62
+5V_USB on L3_PWR: 14.86,90.42 14.86,93.6 13.34,95.12 13.34,97.03 14.35,97.03 14.61,96.77 14.61,96.39 17.53,96.39 18.03,96.9 18.03,99.31 17.4,99.95 17.4,108.2 9.27,108.2 9.14,108.33 9.14,112.65 13.84,112.65 14.22,113.03 20.19,113.03 20.19,90.42
+5V_USB on L6_PWR: 13.34,108.2 9.27,108.2 9.14,108.33 9.14,112.65 13.97,112.65 13.97,110.36 16.89,110.36 16.89,108.08 17.02,107.95 20.19,107.95 20.19,90.42 14.86,90.42 14.86,93.6 13.34,95.12
GND on TOP: 114.05,0.64 114.05,1.32 172.01,1.32 172.01,3.05 114.3,3.05 114.3,33.4 110.57,33.4 110.57,33.02 1.02,33.02 1.02,119.38 23.24,119.38 23.24,113.67 3.56,113.67 1.65,111.76 1.65,107.95 30.23,107.95 30.23,119.38 42.29,119.38 74.04,151.13 151.51,151.13 180.09,122.56 180.09,0.64 ; 89 cut-outs
GND on BOTTOM: 42.42,119.38 74.17,151.13 151.51,151.13 180.09,122.56 180.09,0.64 114.05,0.64 114.05,33.02 1.02,33.02 1.02,119.38 ; 7 cut-outs
GND on BOTTOM: 152.27,70.23 152.27,71.88 156.84,71.88 156.84,72.39 158.88,72.39 158.88,70.23
GND on L2_GND: 42.29,119.38 74.04,151.13 151.51,151.13 180.09,122.56 180.09,0.64 114.05,0.64 114.05,33.02 1.02,33.02 1.02,119.38
GND on L3_PWR: 126.11,12.7 126.11,53.34 108.33,53.34 108.33,60.33 126.11,60.33 126.11,58.42 164.21,58.42 164.21,12.7
GND on L3_PWR: 74.68,150.5 74.68,113.03 83.97,113.03 83.97,113.08 91.97,113.08 91.97,121.51 129.97,121.51 129.97,113.03 150.88,113.03 150.88,150.5
GND on L3_PWR: 73.41,88.9 73.41,79.38 92.46,79.38 92.46,88.9
GND on L4_GND: 42.29,119.38 74.04,151.13 151.51,151.13 180.09,122.56 180.09,0.64 114.05,0.64 114.05,33.02 1.02,33.02 1.02,119.38 ; 3 cut-outs
GND on L5_GND, L7_GND: 42.29,119.38 74.04,151.13 151.51,151.13 180.09,122.56 180.09,0.64 114.05,0.64 114.05,33.02 1.02,33.02 1.02,119.38 ; 4 cut-outs
GND on L6_PWR: 115.32,1.91 115.32,26.04 179.45,26.04 179.45,1.91
AN_OUT on TOP (solid shape): 67.84,130.26 67.84,130.22 68.06,130.01 67.18,129.13 67.18,128.77 67.63,128.32 67.13,127.81 67.04,127.9 66.46,128.48 66.46,129.84 65.94,130.36 65.92,130.38 66.82,131.28
AP_OUT on TOP (solid shape): 63.74,127.12 65.11,127.12 65.77,126.46 65.27,125.96 64.82,126.41 64.46,126.41 63.58,125.53 62.32,126.78 62.52,126.98 63.2,127.66
BN_OUT on TOP (solid shape): 96.79,141.62 97.76,140.66 97.76,139.72 97.05,139.72 97.05,140.35 96.79,140.61 95.55,140.61 95.55,142.38 96.79,142.38
BP_OUT on TOP (solid shape): 101.9,140.94 101.87,140.91 101.87,140.61 100.63,140.61 100.38,140.35 100.38,139.72 99.66,139.72 99.66,140.66 100.63,141.62 100.63,142.38 101.9,142.38
CN_OUT on TOP (solid shape): 130.22,140.94 130.2,140.91 130.2,140.61 128.95,140.61 128.7,140.35 128.7,139.72 127.99,139.72 127.99,139.84 127.99,140.66 128.95,141.62 128.95,142.36 128.95,142.38 130.22,142.38
CP_OUT on TOP (solid shape): 125.12,141.51 125.37,141.25 126.08,140.54 126.08,139.6 125.37,139.6 125.37,140.24 125.12,140.49 123.87,140.49 123.87,142.27 125.12,142.27
DN_OUT on TOP (solid shape): 159.8,130.35 159.26,129.81 159.26,128.44 158.6,127.78 158.09,128.28 158.54,128.73 158.54,129.09 157.84,129.79 157.66,129.97 158.92,131.23
DP_OUT on TOP (solid shape): 163.44,126.75 162.41,125.73 162.38,125.73 162.16,125.52 161.28,126.4 160.92,126.4 160.47,125.95 159.97,126.45 160.06,126.54 160.63,127.11 161.64,127.11 162,127.11 162.52,127.64 162.54,127.65
Net_289 on TOP (solid shape): 99.09,141.05 99.35,141.05 99.35,140.87 99.09,140.62 99.09,139.73 98.33,139.73 98.33,140.62 98.08,140.87 98.08,141.05 98.33,141.05 98.33,142.4 99.09,142.4
Net_290 on TOP (solid shape): 65.78,128.34 65.96,128.52 66.09,128.39 66.09,128.03 66.72,127.41 66.18,126.87 65.55,127.5 65.19,127.5 65.07,127.62 65.25,127.8 64.29,128.75 64.83,129.29
Net_361 on TOP (solid shape): 127.42,131.63 127.67,131.63 127.67,130.59 127.42,130.33 127.42,130.08 127.42,129.44 126.66,129.44 126.66,130.33 126.4,130.59 126.4,131.5 126.43,131.53 126.66,131.53 126.66,132.11 127.42,132.11
Net_362 on TOP (solid shape): 154.16,121.48 153.82,121.14 154,120.96 153.27,120.22 152.91,120.22 152.73,120.04 152.28,119.59 151.74,120.13 152.19,120.58 152.37,120.76 152.37,121.12 153.01,121.77 153.05,121.77 153.21,121.6 153.63,122.02
Net_363 on TOP (solid shape): 127.42,141.05 127.67,141.05 127.67,140.87 127.42,140.62 127.42,139.73 126.66,139.73 126.66,140.36 126.66,140.62 126.4,140.87 126.4,141.05 126.66,141.05 126.66,142.4 127.42,142.4
Net_431 on TOP (solid shape): 99.09,131.63 99.35,131.63 99.35,130.59 99.09,130.33 99.09,129.44 98.33,129.44 98.33,130.33 98.08,130.59 98.08,131.5 98.1,131.53 98.33,131.53 98.33,132.11 99.09,132.11
Net_432 on TOP (solid shape): 72.45,121.68 72.63,121.86 73.36,121.12 73.36,120.76 73.99,120.13 73.45,119.59 72.82,120.22 72.47,120.22 71.82,120.87 71.82,120.9 71.98,121.07 71.57,121.48 72.11,122.02
Net_435 on TOP (solid shape): 161.44,128.75 160.49,127.8 160.67,127.62 160.54,127.5 160.18,127.5 160,127.32 159.55,126.87 159.01,127.41 159.64,128.04 159.64,128.39 159.77,128.52 159.95,128.34 160.9,129.29
OUT_AN on TOP (solid shape): 71.63,126.43 70.77,125.57 70.27,126.07 68.87,126.07 68.2,126.74 68.71,127.24 69.16,126.79 69.51,126.79 70.39,127.67
OUT_AN on TOP (solid shape): 75.35,122.69 74.47,121.81 74.47,121.45 74.92,121 74.41,120.5 73.75,121.17 73.75,122.57 73.26,123.05 73.26,123.09 74.11,123.93
OUT_AP on TOP (solid shape): 70.97,119.84 72.37,119.84 73.03,119.17 72.53,118.67 72.08,119.12 71.72,119.12 70.84,118.24 70.3,118.78 69.6,119.48 70.46,120.34
OUT_AP on TOP (solid shape): 67.51,124.72 67.51,123.32 68,122.83 68,122.8 67.15,121.95 65.92,123.19 66.8,124.07 66.8,124.43 66.35,124.88 66.85,125.38
OUT_BN on TOP (solid shape): 96.78,131.37 97.77,130.38 97.77,129.44 97.06,129.44 97.06,130.08 96.81,130.33 95.56,130.33 95.56,132.08 96.78,132.08
OUT_BN on TOP (solid shape): 97.76,137.28 96.77,136.29 96.77,135.6 96.74,135.58 95.55,135.58 95.55,137.33 96.79,137.33 97.05,137.58 97.05,138.22 97.76,138.22
OUT_BP on TOP (solid shape): 100.38,137.58 100.63,137.33 101.87,137.33 101.87,135.58 100.65,135.58 100.65,136.29 99.66,137.28 99.66,138.22 100.38,138.22
OUT_BP on TOP (solid shape): 101.86,130.33 100.62,130.33 100.36,130.08 100.36,129.44 99.65,129.44 99.65,130.38 100.64,131.37 100.64,132.06 100.67,132.08 101.86,132.08
OUT_CN on TOP (solid shape): 128.7,137.58 128.95,137.33 130.2,137.33 130.2,135.58 128.98,135.58 128.98,136.29 128.7,136.57 127.99,137.28 127.99,138.22 128.7,138.22
OUT_CN on TOP (solid shape): 130.19,130.33 129.83,130.33 128.94,130.33 128.69,130.08 128.69,129.44 127.98,129.44 127.98,130.38 128.69,131.09 128.97,131.37 128.97,132.06 128.99,132.08 130.19,132.08
OUT_CP on TOP (solid shape): 125.11,131.37 126.1,130.38 126.1,129.44 125.39,129.44 125.39,130.08 125.13,130.33 123.89,130.33 123.89,132.08 125.11,132.08
OUT_CP on TOP (solid shape): 126.1,137.3 125.11,136.31 125.11,135.63 125.08,135.6 123.89,135.6 123.89,137.35 125.13,137.35 125.39,137.61 125.39,138.24 126.1,138.24
OUT_DN on TOP (solid shape): 152.51,123.1 152.01,122.59 152.01,122.2 152.01,121.19 151.34,120.53 150.84,121.03 151.29,121.48 151.29,121.84 150.41,122.72 151.65,123.96
OUT_DN on TOP (solid shape): 156.19,126.79 156.55,126.79 157,127.24 157.5,126.74 156.84,126.07 155.44,126.07 154.95,125.59 154.92,125.59 154.07,126.43 155.31,127.67
OUT_DP on TOP (solid shape): 159.4,124.92 158.95,124.47 158.95,124.11 159.83,123.23 158.59,121.99 157.73,122.85 158.23,123.35 158.23,124.76 158.89,125.42
OUT_DP on TOP (solid shape): 156.1,119.5 154.86,118.26 154.65,118.48 154.61,118.52 153.98,119.14 153.63,119.14 153.18,118.69 152.67,119.2 153.34,119.86 154.74,119.86 155.22,120.35 155.26,120.35
N16791900 on TOP: 10.03,88.27 10.03,83.57 12.57,83.57 12.57,88.27
N16791900 on TOP: 14.48,97.92 14.48,96.9 17.27,96.9 17.27,97.92
N16791900 on BOTTOM: 9.02,83.69 9.02,98.55 17.53,98.55 17.53,96.77 12.83,96.77 12.83,83.69
N16791900 on L3_PWR: 10.16,83.57 10.16,88.14 12.57,88.14 12.57,90.3 10.16,90.3 10.16,98.55 10.41,98.81 17.27,98.81 17.4,98.68 17.4,96.9 14.86,96.9 14.22,97.54 12.95,97.54 12.95,93.34 14.22,93.34 14.22,85.72 12.57,84.07 12.57,83.57
N16918679 on TOP, BOTTOM: 92.96,36.45 92.96,37.85 101.35,37.85 101.35,38.74 101.73,39.12 106.55,39.12 106.68,38.99 106.68,36.07 96.9,36.07 96.52,36.45
N16960291 on BOTTOM, L3_PWR, L6_PWR: 23.51,46.74 23.51,47.62 19.19,47.62 19.19,48.39 23.51,48.39 23.51,49.53 33.16,49.53 33.16,46.74
N16991585 on BOTTOM: 167.77,65.53 167.77,71.88 164.08,71.88 164.08,75.06 168.53,75.06 168.53,71.5 168.66,71.5 168.66,65.53
N16991585 on L3_PWR: 166.12,60.2 166.12,61.59 164.34,63.37 164.34,74.04 164.85,74.55 165.48,74.55 165.99,74.04 165.99,72.9 168.4,72.9 168.91,72.39 168.91,60.2
N16991666 on BOTTOM: 168.78,56.52 170.05,56.52 170.05,61.98 168.78,61.98
N16992144 on BOTTOM: 165.86,56.52 162.56,56.52 162.56,60.07 159.77,60.07 159.77,61.98 165.86,61.98
N16992144 on L6_PWR: 164.59,56.52 162.56,56.52 162.56,60.07 160.02,60.07 160.02,61.98 165.86,61.98 165.86,60.07 164.59,60.07
N16992172 on BOTTOM: 170.81,56.39 172.21,56.39 172.21,57.66 173.61,57.66 173.61,62.1 170.81,62.1
N16992172 on L6_PWR: 173.61,58.17 173.61,62.1 171.45,62.1 171.45,58.17
N16994752 on BOTTOM: 166.62,56.64 167.89,56.64 167.89,61.72 166.62,61.72
N17014647 on TOP: 89.03,50.04 89.03,45.72 91.06,45.72 91.06,50.04
N17014647 on BOTTOM: 88.77,50.42 88.77,45.85 91.06,45.85 91.06,50.42
N17014647 on L3_PWR: 93.22,52.96 90.42,52.96 90.42,49.15 88.52,49.15 88.52,52.96 86.23,52.96 86.23,54.99 93.22,54.99
N17015106 on L3_PWR: 84.33,50.55 84.33,51.31 83.31,52.32 81.15,52.32 81.03,52.45 81.03,64.9 82.04,65.91 87.25,65.91 87.25,63.63 87.12,63.5 82.93,63.5 82.93,53.98 83.06,53.85 84.33,53.85 86.49,51.69 86.49,50.55
N17015811 on L6_PWR: 79.5,64.64 79.5,62.99 81.03,62.99 81.03,64.64
N17015820 on L6_PWR: 76.96,61.72 76.96,59.94 79.5,59.94 79.5,61.72
N17015829 on BOTTOM: 78.87,59.18 78.87,57.91 80.64,57.91 80.64,59.18
N17015829 on L6_PWR: 78.87,58.04 78.87,59.31 80.64,59.31 80.64,58.04
N17015838 on L6_PWR: 96.01,57.28 96.01,55.5 97.28,55.5 97.28,57.28
N17267622 on TOP, L6_PWR: 17.27,110.24 17.27,108.33 20.57,108.33 20.57,110.24
N17292342 on TOP (solid shape): 75.7,118.43 76.06,118.43 76.18,118.3 76,118.12 76.96,117.17 76.42,116.63 75.47,117.58 75.29,117.4 75.16,117.53 75.16,117.89 74.53,118.52 75.07,119.05
N17293168 on TOP (solid shape): 99.09,127.03 99.35,126.78 99.35,126.6 99.09,126.6 99.09,125.25 98.33,125.25 98.33,126.6 98.08,126.6 98.08,126.78 98.33,127.03 98.33,127.92 99.09,127.92
N17293265 on TOP (solid shape): 151.2,118.52 150.75,118.07 150.57,117.89 150.57,117.53 150.45,117.4 150.27,117.58 149.31,116.63 148.78,117.17 149.73,118.12 149.55,118.3 149.67,118.43 150.03,118.43 150.66,119.05
N17375290 on TOP (solid shape): 68.42,125.7 68.78,125.7 68.8,125.68 69.43,125.05 69.43,125.02 69.27,124.86 69.68,124.44 69.14,123.9 68.8,124.25 68.62,124.07 67.89,124.8 67.89,125.16 67.26,125.79 67.8,126.33
N17375633 on TOP (solid shape): 78.91,119.13 78.03,118.25 77.49,118.79 76.13,118.79 75.47,119.45 75.97,119.95 76.42,119.5 76.78,119.5 77.48,120.2 77.66,120.38
N17385404 on TOP (solid shape): 99.09,137.32 99.35,137.06 99.35,136.15 99.32,136.12 99.09,136.12 99.09,135.54 98.33,135.54 98.33,136.02 98.08,136.02 98.08,137.06 98.33,137.32 98.33,138.21 99.09,138.21
N17385560 on TOP (solid shape): 97.77,126.98 96.81,126.01 96.81,125.25 95.54,125.25 95.54,126.7 95.56,126.72 95.56,127.03 96.81,127.03 97.06,127.28 97.06,127.92 97.77,127.92
N17385723 on TOP (solid shape): 127.42,137.32 127.67,137.06 127.67,137.04 127.67,136.15 127.65,136.12 127.42,136.12 127.42,135.54 126.66,135.54 126.66,136.02 126.4,136.02 126.4,137.06 126.66,137.32 126.66,137.57 126.66,138.21 127.42,138.21
N17386229 on TOP (solid shape): 127.42,127.28 127.42,127.03 127.67,126.78 127.67,126.6 127.42,126.6 127.42,125.25 126.66,125.25 126.66,126.6 126.4,126.6 126.4,126.78 126.66,127.03 126.66,127.92 127.42,127.92
N17386239 on TOP (solid shape): 128.69,127.28 128.94,127.03 130.19,127.03 130.19,125.25 128.94,125.25 128.94,126.01 128.69,126.27 127.98,126.98 127.98,127.92 128.69,127.92
N17386557 on TOP (solid shape): 158.47,125.79 158.03,125.34 157.85,125.16 157.85,124.8 157.83,124.78 157.2,124.16 157.16,124.16 157,124.32 156.59,123.9 156.05,124.44 156.39,124.78 156.21,124.96 156.95,125.7 157.31,125.7 157.49,125.88 157.94,126.33
N17386789 on TOP (solid shape): 148.96,119.5 149.31,119.5 149.76,119.95 150.27,119.45 149.6,118.78 148.24,118.78 147.72,118.26 147.7,118.25 146.8,119.14 147.82,120.17 147.86,120.17 148.08,120.38
N17392271 on TOP (solid shape): 74.8,117.46 74.8,116.09 75.34,115.55 74.44,114.65 73.42,115.68 73.42,115.71 73.2,115.93 74.08,116.81 74.08,117.17 73.72,117.53 73.63,117.62 74.14,118.12
N17393143 on TOP (solid shape): 100.36,127.28 100.62,127.03 101.86,127.03 101.86,125.25 100.62,125.25 100.62,126.01 99.65,126.98 99.65,127.92 100.36,127.92
N17394079 on TOP (solid shape): 126.1,127.79 126.1,126.98 125.13,126.01 125.13,125.28 125.13,125.25 123.86,125.25 123.86,126.7 123.89,126.72 123.89,127.03 125.13,127.03 125.39,127.28 125.39,127.92 126.1,127.92
N17395163 on TOP (solid shape): 152.1,117.62 151.65,117.17 151.65,116.81 152.53,115.93 151.27,114.67 151.07,114.87 150.39,115.55 150.93,116.09 150.93,117.46 151.6,118.12

## Text on the board
BOTTOM: LAYER 8 (BOTTOM SIDE)
Board Geometry/Soldermask Bottom: SOLDERMASK BOTTOM
Ref Des/Silkscreen Bottom: SILKSCREEN BOTTOM
User.Comments: TEXAS INSTRUMENTS | DAC3XJ8X EVM REV D | TOP VIEW | BOTTOM VIEW
TOP: LAYER 1 (TOP SIDE)
Board Geometry/Soldermask Top: SOLDERMASK TOP
Ref Des/Silkscreen Top: GND | USB | CPLD | VCLK | VDDIO | TEST | +0.9V | +2.5V | DAC38J84 | DAC37J84 | DAC38J82 | DAC37J82 | SILKSCREEN TOP | LMK04828 | DAC3XJ8X REV D
L2_GND: LAYER 2 - GND
L3_PWR: LAYER 3 - POWER
L4_GND: LAYER 4 - GND
L5_GND: LAYER 5 - GND
L6_PWR: LAYER 6 - POWER
L7_GND: LAYER 7 - GND
DIMENSION: PASTEMASK TOP
DISPLAY_TOP: PASTEMASK BOTTOM
ASSEMBLY_DETAIL1: SEE NOTE 3 | 4 PLC'S
User.8: THIS STACK UP DETAIL IS FOR REFERENCE ONLY | USE DDI/VIASYSTEMS STACKUP JOB NAME: DAC38J84_RO4350
User.9: 12-18-12
User.14: FIGURE | SIZE | 8.0 | 10.0 | 12.0 | 15.0 | 38.0 | 40.0 | 62.0 | 67.0 | 106.0 | 120.0 | 140.0 | 39.0 | 50.0 | 53.0 | 125.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | PLATED | NON-PLATED | QTY | 221 | 1424 | 3 | 1754 | 80 | 64 | 44 | 1 | 4 | 2 | 24 | 10
User.18: 1 | 3 | 2 | *
User.19: J22 | R148 | R151 | C207 | C117 | C150 | C143 | C133 | C127 | R173 | C119 | C144 | C134 | U9 | U11 | FB31 | R174 | C135 | C138 | C126 | C129 | L17 | C130 | U7 | FB34 | L18 | R153 | C110 | C146 | U8 | R49 | R72 | C113 | C187 | C174 | C171 | C179 | C14 | R183 | R40 | R193 | C15 | C10 | FB33 | C23 | R192 | C3 | C181 | C11 | C13 | R135 | C33 | C167 | C7 | C180 | C175 | R191 | C9 | R194 | C71 | R184 | R24 | FB9 | SJP2 | FB25 | C363 | C366 | C364 | C365 | C21 | FB3 | FB4 | FB10 | C69 | R185 | FB5 | C87 | C57 | C88 | FB2 | C73 | C59 | C58 | C70 | R71 | FB6 | FB7 | C72 | FB8 | R11 | R57 | C156 | C162 | C165 | R111 | C152 | R110 | C166 | C153 | C155 | C154 | C43 | C159 | C56 | C164 | C157 | C101 | C49 | C158 | C98 | C97 | C100 | C99 | FB24 | C160 | F1 | D9 | C161 | C163 | R93 | U6 | U10 | R92 | C96 | R91 | J23 | R90 | C106 | C182 | C358 | C357 | C22 | C356 | C355 | C360 | C359 | C361 | C362 | C351 | C352 | C17 | C353 | C354 | C136 | R175 | R176 | C147 | C139 | C137 | C128 | C145 | R150 | C149 | C148 | R96 | R97 | R95 | FB30 | R94 | C116 | C108 | C107 | C109 | C32 | C170 | C173 | C186 | C178 | C185 | C184 | C169 | C177 | C183 | C172 | C31 | C345 | C25 | C346 | C26 | FB19 | C343 | C344 | C24 | C176 | C5 | C34 | R136 | C4 | C20 | FB32 | C28 | C27 | C18 | FB29 | R189 | R190 | C66 | C65 | R188 | R187 | R177 | C103 | R143 | C105 | C123 | C104 | C102 | C125 | FB20 | C124 | C235 | Q1 | J16
User.20: C64
