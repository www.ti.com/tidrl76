# Allegro board DAC3XJ8X_D.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
unnamed
  round 1.016 smd: 1(0,0)
unnamed#2
  round 1.016 hole 1.346 unplated: (0,0)
VCXO_6_CUSTOM
  rect 5.74x1.956 smd: 1(-3.81,2.54) 2(-3.81,0) 3(-3.81,-2.54) 4(3.81,-2.54) 5(3.81,0) 6(3.81,2.54)
XTAL_4_SM_130X102
  rect 1.4x1.2 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)

## Nets
1.8V_CPLD: C155.2 C156.2 C162.2 C165.2 C166.2 J15.4 JP3.1(PIN1) JP5.2(PIN2) R110.2 R111.2 U1.9(VCCIO1#9) U1.13(VCCINT#13) U1.31(VCCIO1#31) U1.45(VCCIO1#45) U1.63(VCCINT#63)
1.8V_USB: C43.1 C56.1 C161.2 C163.2 C164.2 JP5.3(PIN3) U3.12(VCORE#12) U3.37(VCORE#37) U3.49(VREGOUT) U3.64(VCORE#64)
3.3V: C97.1 C98.1 C99.1 C100.1 FB24.2 U6.1(OUT1) U6.3(SENSE) U6.20(OUT2)
3.3V_CPLD: C152.2 C153.2 C154.2 C200.1 JP6.2(PIN2) R107.1 U1.59(VCCIO2#59) U1.80(VCCIO2#80) U1.94(VCCIO2#94) U15.5(VCC)
3.3V_USB: C49.1 C151.1 C157.2 C158.2 C159.2 C160.2 C236.2 FB15.1 FB16.1 FB36.2 JP6.3(PIN3) R1.2 R58.2 R60.2 R64.2 U3.20(VCCIO#20) U3.31(VCCIO#31) U3.42(VCCIO#42) U3.50(VREGIN) U3.56(VCCIO#56) U4.6(ORG) U4.8(VCC)
+0.9V_DAC: C137.1 C138.1 C139.1 C345.1 C346.1 C347.1 C348.1 FB18.1 FB19.1 R176.1 R192.1 TP21.1(TP) U9.1(OUT4) U9.18(OUT1) U9.19(OUT2) U9.20(OUT3)
+0.9V_VDDCLK: C6.1 C7.1 C9.1 C349.1 C350.1 FB18.2 PP2.1 U2.A8(VDDCLK09_1) U2.B8(VDDCLK09_2)
+0.9V_VDDDAC: C10.1 C182.1 C183.1 C184.1 C185.1 C186.1 C187.1 C343.1 C344.1 FB19.2 PP3.1 U2.D9(VDDDAC09_1) U2.E9(VDDDAC09_2) U2.F9(VDDDAC09_3) U2.G9(VDDDAC09_4) U2.H9(VDDDAC09_5) U2.J9(VDDDAC09_6)
+0.9V_VDDDIG: C11.1 C13.1 C14.1 C146.1 C149.1 C171.1 C174.1 C175.1 C176.1 C177.1 C178.1 C179.1 C180.1 C181.1 FB30.3 PP9.1 TP28.1(TP) U2.D3(VDDDIG09_1) U2.D4(VDDDIG09_2) U2.D5(VDDDIG09_8) U2.E4(VDDDIG09_3) U2.F4(VDDDIG09_4) U2.G4(VDDDIG09_5) U2.H4(VDDDIG09_6) U2.J4(VDDDIG09_7) U2.J5(VDDDIG09_9) U2.J6(VDDDIG09_10) U2.J7(VDDDIG09_11)
+0.9V_VDDT: C3.1 C4.1 C5.1 PP1.1 R192.2 U2.F3(VDDT09_1) U2.G3(VDDT09_2)
+1.8V_DAC: C128.1 C129.1 C130.1 C353.1 C354.1 C361.1 C362.1 C365.1 C366.1 FB25.1 FB29.1 FB32.1 R174.1 R193.1 R194.1 TP26.1(TP) U11.1(OUT4) U11.18(OUT1) U11.19(OUT2) U11.20(OUT3)
+1.8V_VDDAPLL: C17.1 C25.1 C26.1 C351.1 C352.1 FB25.2 PP5.1 U2.B9(VDDAPLL18_1) U2.B10(VDDAPLL18_2)
+1.8V_VDDAREF: C20.1 C31.1 C32.1 C359.1 C360.1 FB32.2 PP10.1 U2.C10(VDDAREF18_1) U2.K10(VDDAREF18_2)
+1.8V_VDDIO: C15.1 C23.1 C24.1 JP1.1(PIN1) JP4.1(PIN1) JP5.1(PIN1) PP4.1 R63.1 R193.2 U2.K6(VDDIO18_1) U2.K7(VDDIO18_2)
+1.8V_VDDR: C21.1 C33.1 C34.1 C363.1 C364.1 FB29.2 PP11.1 U2.F2(VDDR18_1) U2.G2(VDDR18_2)
+1.8V_VDDS: C18.1 C27.1 C28.1 PP7.1 R191.1 R194.2 U2.C6(VDDS18_1) U2.C7(VDDS18_2)
+2.5V_LDO_IN: C119.1 C126.1 C135.1 C144.1 FB31.3 TP20.1(TP) U9.5(IN1) U9.6(IN2) U9.7(IN3) U9.8(IN4) U9.11(EN) U11.5(IN1) U11.6(IN2) U11.7(IN3) U11.8(IN4) U11.11(EN)
+3.3V_DAC: C108.1 C109.1 C110.1 C113.1 C127.1 C134.1 C357.1 C358.1 FB33.1 TP18.1(TP) U8.1(OUT1) U8.3(SENSE) U8.20(OUT2) U9.10(BIAS) U11.10(BIAS)
+3.3V_VDDADAC: C22.1 C169.1 C170.1 C172.1 C173.1 C355.1 C356.1 FB33.2 PP6.1 U2.D10(VDDADAC33_1) U2.E10(VDDADAC33_2) U2.H10(VDDADAC33_3) U2.J10(VDDADAC33_4)
+3.3VCLK: C69.1 C70.1 C71.1 C72.1 C73.1 C101.1 C102.1 C103.1 C104.1 C105.1 FB2.1 FB3.1 FB6.1 FB7.1 FB8.1 FB9.1 FB10.1 FB24.1 FB36.1 JP2.2 JP6.1(PIN1) R73.1 R78.1 SJP1.1(PIN1) TP17.1(TP)
+5.0V: C96.1 C107.1 C123.1 C125.1 D2.1(ANODE) D3.1(ANODE) D11.1(ANODE) FB20.1 FB34.1 R143.2 TP19.1(TP) U6.13(EN) U6.15(IN2) U6.16(IN1) U8.13(EN) U8.15(IN2) U8.16(IN1)
+5V_IN: F1.1 J23.1 Q1.1(D1) Q1.2(D2) Q1.5(D5) Q1.6(D6) Q1.8(D8) TP29.1(TP) U10.5(VIN)
+5V_USB: C41.1 C54.1 R51.1 R53.1 R101.1 R178.1 SJP3.3(PIN3) TP13.1(TP) U12.1(IN)
GND: C3.2 C4.2 C5.2 C6.2 C7.2 C9.2 C10.2 C11.2 C13.2 C14.2 C15.2 C17.2 C18.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C31.2 C32.2 C33.2 C34.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C63.2 C64.2 C65.2 C66.2 C69.2 C70.2 C71.2 C72.2 C73.2 C78.1 C81.1 C84.1 C85.1 C87.2 C88.2 C90.1 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C109.2 C110.2 C113.2 C116.2 C117.2 C119.2 C120.1 C121.1 C123.2 C124.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C133.2 C134.2 C135.2 C136.2 C137.2 C138.2 C139.2 C143.2 C144.2 C145.2 C146.2 C147.2 C149.2 C150.2 C151.2 C152.1 C153.1 C154.1 C155.1 C156.1 C157.1 C158.1 C159.1 C160.1 C161.1 C162.1 C163.1 C164.1 C165.1 C166.1 C167.2 C168.2 C169.2 C170.2 C171.2 C172.2 C173.2 C174.2 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C199.2 C200.2 C207.1 C235.2 C236.1 C343.2 C344.2 C345.2 C346.2 C347.2 C348.2 C349.2 C350.2 C351.2 C352.2 C353.2 C354.2 C355.2 C356.2 C357.2 C358.2 C359.2 C360.2 C361.2 C362.2 C363.2 C364.2 C365.2 C366.2 D1.2(CATHODE) D4.2(CATHODE) D5.2(CATHODE) D6.2(CATHODE) D7.2(CATHODE) D8.2(CATHODE) D9.1(A) FB30.2 FB31.2 GP1.1 GP2.1 GP3.1 GP4.1 GP5.1 GP6.1 GP7.1 GP8.1 J1.2(SHIELD1) J2.2(GND#2) J2.3(GND#3) J2.4(GND#4) J2.5(GND#5) J3.2(SHIELD1) J4.2(GND#2) J4.3(GND#3) J4.4(GND#4) J4.5(GND#5) J5.2(SHIELD1) J6.2(GND#2) J6.3(GND#3) J6.4(GND#4) J6.5(GND#5) J7.2(SHIELD1) J8.2(GND#2) J8.3(GND#3) J8.4(GND#4) J8.5(GND#5) J9.2(GND#2) J9.3(GND#3) J9.4(GND#4) J9.5(GND#5) J10.2(GND#2) J10.3(GND#3) J10.4(GND#4) J10.5(GND#5) J11.2(GND#2) J11.3(GND#3) J11.4(GND#4) J11.5(GND#5) J12.2(GND#2) J12.3(GND#3) J12.4(GND#4) J12.5(GND#5) J13.2(SHIELD1) J14.5(GND) J14.6(GND1) J14.7(GND2) J14.8(GND3) J14.9(GND4) J15.2 J15.10 J16.A1 J16.A4 J16.A5 J16.A8 J16.A9 J16.A12 J16.A13 J16.A16 J16.A17 J16.A20 J16.A21 J16.A24 J16.A25 J16.A28 J16.A29 J16.A32 J16.A33 J16.A36 J16.A37 J16.A40 J16.B2 J16.B3 J16.B6 J16.B7 J16.B10 J16.B11 J16.B14 J16.B15 J16.B18 J16.B19 J16.B22 J16.B23 J16.B26 J16.B27 J16.B30 J16.B31 J16.B34 J16.B35 J16.B38 J16.B39 J16.C1 J16.C4 J16.C5 J16.C8 J16.C9 J16.C12 J16.C13 J16.C16 J16.C17 J16.C20 J16.C21 J16.C24 J16.C25 J16.C28 J16.C29 J16.C32 J16.C33 J16.C36 J16.C38 J16.C40 J16.D2 J16.D3 J16.D6 J16.D7 J16.D10 J16.D13 J16.D16 J16.D19 J16.D22 J16.D25 J16.D28 J16.D37 J16.D39 J16.E1 J16.E4 J16.E5 J16.E8 J16.E11 J16.E14 J16.E17 J16.E20 J16.E23 J16.E26 J16.E29 J16.E32 J16.E35 J16.E38 J16.E40 J16.F2 J16.F3 J16.F6 J16.F9 J16.F12 J16.F15 J16.F18 J16.F21 J16.F24 J16.F27 J16.F30 J16.F33 J16.F36 J16.F39 J16.G1 J16.G4 J16.G5 J16.G8 J16.G11 J16.G14 J16.G17 J16.G20 J16.G23 J16.G26 J16.G29 J16.G32 J16.G35 J16.G38 J16.G40 J16.H3 J16.H6 J16.H9 J16.H12 J16.H15 J16.H18 J16.H21 J16.H24 J16.H27 J16.H30 J16.H33 J16.H36 J16.H39 J16.J1 J16.J4 J16.J5 J16.J8 J16.J11 J16.J14 J16.J17 J16.J20 J16.J23 J16.J26 J16.J29 J16.J32 J16.J35 J16.J38 J16.J40 J16.K2 J16.K3 J16.K6 J16.K9 J16.K12 J16.K15 J16.K18 J16.K21 J16.K24 J16.K27 J16.K30 J16.K33 J16.K36 J16.K39 J17.2(GND#2) J17.3(GND#3) J17.4(GND#4) J17.5(GND#5) J18.2(SHIELD1) J19.2(SHIELD1) J20.2(SHIELD1) J21.2 J21.4 J21.6 J21.8 J22.2(SHIELD1) J23.2 J23.3 J24.1 J24.3 J24.5 J24.7 J24.9 J24.11 J24.13 J24.15 J24.17 J24.19 J25.1 J25.3 J25.5 J25.7 J25.9 J25.11 J25.13 J25.15 J25.17 J25.19 JP1.3(PIN3) JP3.3(PIN3) JP4.3(PIN3) Q2.2(E) Q3.2(E) Q4.2(E) R3.1 R6.1 R8.2 R10.1 R11.2 R12.1 R13.1 R15.1 R19.1 R20.1 R22.2 R23.2 R24.2 R26.2 R28.2 R29.2 R31.2 R32.1 R34.2 R35.2 R36.2 R37.2 R39.2 R40.2 R41.1 R44.2 R45.1 R48.2 R49.2 R52.2 R57.2 R61.1 R65.2 R66.2 R67.2 R68.2 R69.2 R70.2 R71.2 R72.1 R74.2 R75.2 R76.2 R77.2 R79.2 R80.2 R83.2 R84.2 R87.2 R89.2 R90.1 R91.1 R92.1 R93.1 R94.1 R95.1 R96.1 R97.1 R98.2 R99.2 R100.2 R102.1 R103.1 R104.2 R112.1 R114.2 R115.1 R116.1 R117.1 R118.2 R122.2 R123.2 R124.2 R125.2 R129.1 R130.1 R131.2 R132.1 R134.2 R136.1 R151.1 R153.1 R173.1 R175.2 R178.2 R179.2 R180.2 R181.2 R182.2 R183.2 R184.1 R195.1 R196.2 R197.1 R198.2 R199.1 R200.2 R201.1 R202.2 SJP1.3(PIN3) SJP3.1(PIN1) SW1.1 SW1.2 SW2.1 SW2.2 TP3.1(TP) TP4.1(TP) TP5.1(TP) TP6.1(TP) TP7.1(TP) TP8.1(TP) TP9.1(TP) TP10.1(TP) TP11.1(TP) TP12.1(TP) TP22.1(TP) TP27.1(TP) U1.1(GND#1) U1.10(GND#10) U1.11(GND#11) U1.32(GND#32) U1.46(GND#46) U1.60(GND#60) U1.65(GND#65) U1.79(GND#79) U1.93(GND#93) U2.A4(GND38) U2.A5(GND32) U2.A11(GND5) U2.A12(GND1) U2.B2(GND44) U2.B3(GND41) U2.B4(GND39) U2.B5(GND33) U2.B11(GND6) U2.C2(GND45) U2.C3(GND42) U2.C8(GND17) U2.C11(GND7) U2.D2(GND46) U2.D8(GND18) U2.D11(GND8) U2.E2(GND47) U2.E5(GND34) U2.E6(GND28) U2.E7(GND24) U2.E8(GND19) U2.E11(GND9) U2.F5(GND35) U2.F6(GND29) U2.F7(GND25) U2.F8(GND20) U2.F11(GND10) U2.F12(GND2) U2.G5(GND36) U2.G6(GND30) U2.G7(GND26) U2.G8(GND21) U2.G11(GND11) U2.G12(GND3) U2.H2(GND48) U2.H5(GND37) U2.H6(GND31) U2.H7(GND27) U2.H8(GND22) U2.H11(GND12) U2.J2(GND49) U2.J8(GND23) U2.J11(GND13) U2.K2(GND50) U2.K11(GND14) U2.L2(GND51) U2.L3(GND43) U2.L11(GND15) U2.M4(GND40) U2.M11(GND16) U2.M12(GND4) U3.1(GND#1) U3.5(GND#5) U3.10(AGND) U3.11(GND#11) U3.13(TEST) U3.15(GND#15) U3.25(GND#25) U3.35(GND#35) U3.47(GND#47) U3.51(GND#51) U4.5(GND) U5.65(DAP) U6.7(GND) U6.21(PWRPAD) U7.8(GND) U7.11(THERMPAD) U8.7(GND) U8.21(PWRPAD) U9.2(NC1) U9.3(NC2) U9.4(NC3) U9.12(GND) U9.13(NC4) U9.14(NC5) U9.17(NC6) U9.21(PWRPAD) U10.2(GND) U11.2(NC1) U11.3(NC2) U11.4(NC3) U11.12(GND) U11.13(NC4) U11.14(NC5) U11.17(NC6) U11.21(PWRPAD) U12.2(GND) U15.3(GND) Y1.3(GND) Y2.2 Y2.4
ALARM: TP24.1(TP) U2.L8(ALARM)
AMUX0: TP2.1(TP) U2.H3(AMUX0)
AMUX1: TP1.1(TP) U2.E3(AMUX1)
AN_OUT: R12.2 R14.1 T2.4(PRIMARY)
ANOUT: J4.1(CENTER) R14.2
AP_OUT: R2.2 R15.2 T2.6(PRIMARY_DOT)
APOUT: J2.1(CENTER) R2.1
ATEST: TP23.1(TP) U2.K9(ATEST)
BN_OUT: R22.1 R27.1 T4.6(PRIMARY_DOT)
BNOUT: J8.1(CENTER) R27.2
BP_OUT: R17.1 R19.2 T4.4(PRIMARY)
BPOUT: J6.1(CENTER) R17.2
CAR_SYSREFM: J16.G10 R108.2
CAR_SYSREFP: J16.G9 R109.2
CLK_IN: C122.1 R100.1 R177.2
CLK_LAO_0M: C89.1 J16.G7
CLK_LAO_0P: C86.1 J16.G6
CLKIN: J17.1(CENTER) R177.1 R185.1
CLKIN1N: C78.2 C198.2 U5.35(CLKIN1N/FBCLKINN/FINN)
CLKIN1P: C122.2 U5.34(CLKIN1P/FBCLKINP/FINP)
CLKLA_0N: C89.2 R80.1 U5.63(DCLKOUT12N)
CLKLA_0P: C86.2 R79.1 U5.62(DCLKOUT12P)
CLKN: C340.2 R18.2 R182.1
CLKOUT0_N: C83.2 J18.1(CENTER)
CLKOUT0_P: C79.2 J13.1(CENTER)
CLKOUT1_N: C93.2 J20.1(CENTER)
CLKOUT1_P: C91.2 J19.1(CENTER)
CLKP: C341.2 R16.2 R181.1
CMOS_SYNC_AB: J16.F20 J21.1 U2.L6(NC1)
CMOS_SYNC_CD: J16.F19 J21.3 U2.L7(NC2)
CN_OUT: R41.2 R42.1 T6.4(PRIMARY)
CNOUT: J10.1(CENTER) R42.2
CP1: C60.1 C61.1 C120.2 U5.32(CPOUT1) Y1.1(VC)
CP2: C62.1 C63.1 U5.46(CPOUT2)
CP_OUT: R30.1 R102.2 T6.6(PRIMARY_DOT)
CPLD_SYNC: SJP2.3(PIN3) U1.82(IO_2_82/DIFFIO_T8P)
CPOUT: J9.1(CENTER) R30.2
DAC_RESET: C168.1 R63.2 SW1.3 SW1.4 U1.37(IO_1_37/DIFFIO_B5N) U2.K8(RESETB)
DAC_SCLK: U1.33(IO_1_33/DIFFIO_B3N) U2.L9(SCLK)
DAC_SDENB: U1.34(IO_1_34/DIFFIO_B4P) U2.M9(SDENB)
DAC_SDIO: U1.35(IO_1_35/DIFFIO_B4N) U2.L10(SDIO)
DAC_SDO: U1.36(IO_1_36/DIFFIO_B5P) U2.M10(SDO)
DAC_TCLK: U1.40(IO_1_40/DIFFIO_B6N) U2.K4(TCLK)
DAC_TDI: U1.41(IO_1_41/DIFFIO_B7P) U2.L5(TDI)
DAC_TDO: U1.42(IO_1_42/DIFFIO_B7N) U2.M5(TDO)
DAC_TMS: U1.43(IO_1_43/DEV_OE/DIFFIO_B8P) U2.L4(TMS)
DAC_TRSTB: U1.44(IO_1_44/DEV_CLRN/DIFFIO_B5N) U2.J3(TRSTB)
DCLK_N: C16.2 R13.2 R18.1 R188.2 U2.A9(DACCLKN)
DCLK_P: C12.2 R16.1 R112.2 R187.2 U2.A10(DACCLKP)
DCLKOUT0N: C83.1 R76.1 U5.28(DCLKOUT6N)
DCLKOUT0P: C79.1 R75.1 U5.27(DCLKOUT6P)
DCLKOUT2N: C340.1 R179.1 U5.15(DCLKOUT2P)
DCLKOUT2P: C341.1 R180.1 U5.16(DCLKOUT2N)
DCLKOUT8N: C74.1 R122.1 U5.52(DCLKOUT8N)
DCLKOUT8P: C75.1 R123.1 U5.51(DCLKOUT8P)
DN_OUT: R50.1 R103.2 T8.6(PRIMARY_DOT)
DNOUT: J11.1(CENTER) R50.2
DP0_C2M_N_A: C190.1 J16.C3
DP0_C2M_P_A: C191.1 J16.C2
DP1_C2M_N_A: C193.1 J16.A23
DP1_C2M_P_A: C192.1 J16.A22
DP2_C2M_N_A: C195.1 J16.A27
DP2_C2M_P_A: C194.1 J16.A26
DP3_C2M_N_A: C197.1 J16.A31
DP3_C2M_P_A: C196.1 J16.A30
DP4_C2M_N_A: C189.1 J16.A35
DP4_C2M_P_A: C188.1 J16.A34
DP5_C2M_N_A: C40.1 J16.A39
DP5_C2M_P_A: C39.1 J16.A38
DP6_C2M_N_A: C38.1 J16.B37
DP6_C2M_P_A: C37.1 J16.B36
DP7_C2M_N_A: C36.1 J16.B33
DP7_C2M_P_A: C35.1 J16.B32
DP_OUT: R43.1 R44.1 T8.4(PRIMARY)
DPOUT: J12.1(CENTER) R43.2
EEDATA: R59.1 U3.61(EEDATA) U4.3(DI)
EXTIO: C167.1 TP14.1(TP) U2.F10(EXTIO)
FMC_B5: J16.G16 U1.7(IO_1_7/DIFFIO_L3N)
FMC_B6: J16.H16 U1.8(IO_1_8)
FMC_DACCLK_N: J16.D9 R188.1
FMC_DACCLK_P: J16.D8 R187.1
FMC_DIR_CONTROL: J16.H17 U1.15(IO_1_15)
FMC_SCLK: J16.C14 U1.2(IO_1_2/DIFFIO_L1P)
FMC_SDIO: J16.C15 U1.3(IO_1_3/DIFFIO_L1N)
FMC_SDO: J16.D14 U1.4(IO_1_4/DIFFIO_L2P)
FMC_SEN_DAC: J16.D15 U1.5(IO_1_5/DIFFIO_L2N)
FMC_SEN_LMK: J16.G15 U1.6(IO_1_6/DIFFIO_L3P)
FMC_SYSREF_N: J16.D12 R189.1
FMC_SYSREF_P: J16.D11 R190.1
FPGA_CLK1N: C74.2 J16.K5
FPGA_CLK1P: C75.2 J16.K4
FPGA_CLK2N: C95.2 J16.J3
FPGA_CLK2P: C94.2 J16.J2
FTDI_A5: U1.70(IO_2_70) U3.22(ADBUS5)
FTDI_A6: U1.69(IO_2_69/DIFFIO_R3P) U3.23(ADBUS6)
FTDI_A7: U1.68(IO_2_68/DIFFIO_R3N) U3.24(ADBUS7)
FTDI_DAC_SDIO_READ: U1.54(IO_2_54/DIFFIO_R7P) U3.44(CDBUS5)
FTDI_DIR_CONTROL: U1.52(IO_2_52) U3.46(CDBUS7)
FTDI_LMK_SDIO_READ: U1.53(IO_2_53/DIFFIO_R7N) U3.45(CDBUS6)
FTDI_SCLK: U1.61(IO_2_61) U3.38(CDBUS0)
FTDI_SDIO: U1.58(IO_2_58/DIFFIO_R5P) U3.39(CDBUS1)
FTDI_SDO: U1.57(IO_2_57/DIFFIO_R5N) U3.40(CDBUS2)
FTDI_SEN_DAC: U1.56(IO_2_56/DIFFIO_R6P) U3.41(CDBUS3)
FTDI_SEN_LMK: U1.55(IO_2_55/DIFFIO_R6N) U3.43(CDBUS4)
FTDI_TCK: U1.75(IO_2_75/DIFFIO_T10N) U3.16(ADBUS0)
FTDI_TDI: U1.74(IO_2_74/DIFFIO_R1P) U3.17(ADBUS1)
FTDI_TDO: U1.73(IO_2_73/DIFFIO_R1N) U3.18(ADBUS2)
FTDI_TMS: U1.72(IO_2_72/DIFFIO_R2P) U3.19(ADBUS3)
FTDI_TRSTB: U1.71(IO_2_71/DIFFIO_R2N) U3.21(ADBUS4)
GTX_CLKM: C68.2 J16.D5
GTX_CLKP: C67.2 J16.D4
GTXCLKM: C68.1 R68.1 U5.2(DCLKOUT0N)
GTXCLKP: C67.1 R67.1 U5.1(DCLKOUT0P)
IFORCE: TP15.1(TP) U2.C5(IFORCE)
IOUTAN: R8.1 R9.1 R39.1 R117.2 U2.C12(IOUTAN)
IOUTAP: R3.2 R5.1 R36.1 R114.1 U2.B12(IOUTAP)
IOUTBN: R23.1 R25.1 R35.1 R129.2 U2.D12(IOUTBN)
IOUTBP: R20.2 R21.1 R34.1 R118.1 U2.E12(IOUTBP)
IOUTCN: R31.1 R37.1 R38.1 R131.1 U2.J12(IOUTCN)
IOUTCP: R29.1 R32.2 R33.1 R130.2 U2.H12(IOUTCP)
IOUTDN: R28.1 R47.1 R48.1 R134.1 U2.K12(IOUTDN)
IOUTDP: R26.1 R45.2 R46.1 R132.2 U2.L12(IOUTDP)
J1_P: C12.1 J1.1(CENTER)
J3_N: C16.1 J3.1(CENTER)
J5_P: C1.1 J5.1(CENTER)
J7_N: C8.1 J7.1(CENTER)
LMK_CS: U1.78(IO_2_78/DIFFIO_T9P) U5.18(\\C\S\)
LMK_SCK: U1.77(IO_2_77/DIFFIO_T9N) U5.19(SCK)
LMK_SDIO: U1.76(IO_2_76/DIFFIO_T10P) U5.20(SDIO)
LMK_SDO: R113.2 U5.5(RESET)
LMK_SYNC: SJP2.2(PIN2) U5.6(SYNC)
LPF: R133.2 U2.C9(LPF)
OSCI: C42.1 U3.2(OSCI) Y2.1
OSCIN_N: C82.2 U5.44(OSCINN)
OSCIN_P: C92.2 C121.2 U5.43(OSCINP)
OSCO: C55.1 U3.3(OSCO) Y2.3
OUT_AN: T1.1(PRIMARY) T2.3(SECONDARY)
OUT_AP: T1.3(PRIMARY_DOT) T2.1(SECONDARY_DOT)
OUT_BN: T3.3(PRIMARY_DOT) T4.1(SECONDARY_DOT)
OUT_BP: T3.1(PRIMARY) T4.3(SECONDARY)
OUT_CN: T5.1(PRIMARY) T6.3(SECONDARY)
OUT_CP: T5.3(PRIMARY_DOT) T6.1(SECONDARY_DOT)
OUT_DN: T7.3(PRIMARY_DOT) T8.1(SECONDARY_DOT)
OUT_DP: T7.1(PRIMARY) T8.3(SECONDARY)
RX0N: C190.2 U2.M2(RX3N)
RX0P: C191.2 U2.M3(RX3P)
RX1N: C193.2 U2.M1(RX2N)
RX1P: C192.2 U2.L1(RX2P)
RX2N: C195.2 U2.J1(RX1N)
RX2P: C194.2 U2.K1(RX1P)
RX3N: C197.2 U2.H1(RX0N)
RX3P: C196.2 U2.G1(RX0P)
RX4N: C189.2 U2.D1(RX5N)
RX4P: C188.2 U2.C1(RX5P)
RX5N: C40.2 U2.A2(RX7N)
RX5P: C39.2 U2.A3(RX7P)
RX6N: C38.2 U2.A1(RX6N)
RX6P: C37.2 U2.B1(RX6P)
RX7N: C36.2 U2.E1(RX4N)
RX7P: C35.2 U2.F1(RX4P)
SDCLKOUT1N: C93.1 R84.1 U5.30(SDCLKOUT7N)
SDCLKOUT1P: C91.1 R83.1 U5.29(SDCLKOUT7P)
SDCLKOUT3N: R89.1 R106.1 U5.13(SDCLKOUT3P)
SDCLKOUT3P: R98.1 R105.1 U5.14(SDCLKOUT3N)
SDCLKOUT9N: C95.1 R125.1 U5.50(SDCLKOUT9N)
SDCLKOUT9P: C94.1 R124.1 U5.49(SDCLKOUT9P)
SLEEP: JP4.2(PIN2) U2.M8(SLEEP)
SYNC: J22.1(CENTER) SJP2.1(PIN1)
SYNCN: J16.F11 U2.B6(SYNCBN)
SYNCP: J16.F10 U2.B7(SYNCBP)
SYS_N: C8.2 R6.2 R7.1 R189.2 U2.A6(SYSREFN)
SYS_P: C1.2 R4.1 R10.2 R190.2 U2.A7(SYSREFP)
SYSREF_M: R70.1 R108.1 U5.4(SDCLKOUT1N)
SYSREF_P: R69.1 R109.1 U5.3(SDCLKOUT1P)
SYSREFN: R7.2 R106.2 R116.2
SYSREFP: R4.2 R105.2 R115.2
TCK: J15.1 R57.1 U1.24(TCK)
TDI: J15.9 R110.1 U1.23(TDI)
TDO: J15.3 U1.25(TDO)
TESTMODE: TP25.1(TP) U2.K3(TESTMODE)
TMS: J15.5 R111.1 U1.22(TMS)
TXENABLE: JP1.2(PIN2) U2.K5(TXENABLE)
USB_DM: C51.1 R56.2 U3.7(DM)
USB_DP: C52.1 R55.2 U3.8(DP)
USB_EECLK: R60.1 U3.62(EECLK) U4.2(CLK)
USB_EECS: R58.1 U3.63(EECS) U4.1(CS)
USB_REF: R52.1 U3.6(REF)
USB_RST: R54.2 U3.14(RESET)
VSENSE: TP16.1(TP) U2.C4(VSENSE)
N16791695: C47.1 U12.4(NC)
N16791764: J14.1(VBUS) R51.2
N16791900: C44.1 C45.1 FB16.2 U3.4(VPHY)
N16791904: C46.1 C48.1 FB15.2 U3.9(VPLL)
N16792038: J14.3(D+) R55.1
N16792040: J14.2(D-) R56.1
N16792068: R53.2 R54.1 R61.2
N16792392: R59.2 R64.1 U4.4(DO)
N16905345: C53.1 R62.1 R133.1
N16905395: C50.1 R62.2
N16906481: R135.1 U2.G10(RBIAS)
N16906487: R135.2 R136.2
N16918679: C81.2 C84.2 C85.2 C90.2 FB17.1 Y1.6(VDD)
N16918713: R78.2 R87.1 R88.1 Y1.5(OUT_P)
N16918734: R73.2 R74.1 R138.1 Y1.4(OUT_N)
N16918766: FB17.2 JP2.1
N16918796: C80.1 R138.2
N16918798: C80.2 C82.1 R77.1
N16918863: C92.1 C206.2 R99.1 R186.2
N16918987: SJP1.2(PIN2) Y1.2(NC)
N16957588: R173.2 R174.2 U11.16(FB/SNS)
N16960291: C124.1 C235.1 F1.2 FB20.2 Q1.4(S4) Q1.7(S7)
N16960299: D9.2(C) Q1.3(G3) U10.4(GATE)
N16974113: R113.1 U1.81(IO_2_81/DIFFIO_T8N)
N16976956: JP3.2(PIN2) U1.51(IO_1_51/DIFFIO_B10N)
N16991585: C117.1 C143.1 C150.1 C207.2 FB34.2 U7.2(MODE/DATA) U7.3(VIN) U7.7(EN1) U7.9(EN2)
N16991666: L17.1 U7.6(SW1)
N16991670: R148.1 R151.2 U7.5(DEF_1)
N16991672: C148.2 R150.1 R153.2 U7.1(ADJ2)
N16992144: C145.1 C148.1 FB30.1 L18.2 R150.2
N16992172: C147.1 FB31.1 L17.2 R148.2 U7.4(FB1)
N16994752: L18.1 U7.10(SW2)
N17000669: R175.1 R176.2 U9.16(FB/SNS)
N17014647: C64.1 C65.1 C66.1 FB3.2 FB4.1 FB5.1 U5.42(VCC8_OSCIN) U5.47(VCC10_PLL2)
N17015106: C57.1 C58.1 C59.1 FB2.2 U5.10(VCC1_VCO) U5.33(VCC5_DIG) U5.36(VCC6_PLL1)
N17015690: FB4.2 U5.45(VCC9_CP2)
N17015695: FB5.2 U5.39(VCC7_OSCOUT)
N17015811: FB6.2 U5.17(VCC2_GC1)
N17015820: FB8.2 U5.21(VCC3_SYSREF)
N17015829: FB7.2 U5.26(VCC4_CG2)
N17015838: FB9.2 U5.53(VCC11_CG3)
N17015851: FB10.2 U5.64(VCC12_CG0)
N17033325: D8.1(ANODE) R101.2
N17045898: C206.1 R88.2
N17071256: J21.5 U2.M7(NC4)
N17071268: J21.7 U2.M6(NC3)
N17135362: C198.1 R104.1
N17199056: C199.1 R107.2 SW2.3 SW2.4 U15.2(A)
N17199129: U1.88(IO_2_88/DIFFIO_T5P) U15.4(Y)
N17201332: D1.1(ANODE) R143.1
N17206708: J24.2 U1.16(IO_1_16/DIFFIO_L4P)
N17206717: J24.4 U1.17(IO_1_17/DIFFIO_L4N)
N17206727: J24.6 U1.18(IO_1_18/DIFFIO_L5P)
N17206729: J24.8 U1.19(IO_1_19/DIFFIO_L5N)
N17206761: J24.10 U1.20(IO_1_20/DIFFIO_L6P)
N17206763: J24.12 U1.21(IO_1_21/DIFFIO_L6N)
N17206775: J24.14 U1.26(IO_1_26/DIFFIO_B1P)
N17206777: J24.16 U1.27(IO_1_27/DIFFIO_B1N)
N17206789: J24.18 U1.28(IO_1_28/DIFFIO_B2P)
N17206791: J24.20 U1.29(IO_1_29/DIFFIO_B2N)
N17207204: J25.2 U1.89(IO_2_89/DIFFIO_T4N)
N17207206: J25.4 U1.90(IO_2_90/DIFFIO_T4P)
N17207236: J25.6 U1.91(IO_2_91)
N17207238: J25.8 U1.92(IO_2_92/DIFFIO_T3N)
N17207240: J25.10 U1.95(IO_2_95/DIFFIO_T3P)
N17207242: J25.12 U1.96(IO_2_96/DIFFIO_T2N)
N17207244: J25.14 U1.97(IO_2_97/DIFFIO_T2P)
N17207246: J25.16 U1.98(IO_2_98/DIFFIO_T1N)
N17207248: J25.18 U1.99(IO_2_99/DIFFIO_T1P)
N17207250: J25.20 U1.100(IO_2_100)
N17211055: R1.1 U12.5(OUT)
N17267622: SJP3.2(PIN2) U12.3(EN)
N17273566: Q3.1(B) R119.2
N17273570: Q4.1(B) R120.2
N17273576: J16.D18 R120.1
N17273599: J16.D17 R119.1
N17274139: Q3.3(C) R127.2
N17274205: Q2.1(B) R121.2
N17277740: D2.2(CATHODE) R127.1
N17277758: D3.2(CATHODE) R126.1
N17277849: D11.2(CATHODE) R128.1
N17292342: R71.1 T1.5(SECONDARY_CT)
N17293168: R184.2 T3.5(SECONDARY_CT)
N17293265: R72.2 T7.5(SECONDARY_CT)
N17316333: R185.2 R186.1
N17352995: R191.2 U2.D6(VQPS18_1) U2.D7(VQPS18_2)
N17375290: R11.1 T2.2(UNUSED)
N17375633: R9.2 R196.1 T1.6(SECONDARY)
N17385404: R24.1 T4.2(UNUSED)
N17385560: R25.2 R198.1 T3.4(SECONDARY_DOT)
N17385723: R40.1 T6.2(UNUSED)
N17386229: R183.1 T5.5(SECONDARY_CT)
N17386239: R38.2 R200.1 T5.6(SECONDARY)
N17386557: R49.1 T8.2(UNUSED)
N17386789: R47.2 R202.1 T7.4(SECONDARY_DOT)
N17392271: R5.2 R195.2 T1.4(SECONDARY_DOT)
N17393143: R21.2 R197.2 T3.6(SECONDARY)
N17394079: R33.2 R199.2 T5.4(SECONDARY_DOT)
N17395163: R46.2 R201.2 T7.6(SECONDARY)
N18118787: C106.1 U6.14(NR)
N18138734: D6.1(ANODE) R85.1
N18138778: D5.1(ANODE) R82.1
N18138841: D7.1(ANODE) R86.1
N18138859: R86.2 U5.48(STATUS_LD2)
N18139187: R85.2 U5.31(STATUS_LD1)
N18494750: R91.2 U6.11(0P2V)
N18494760: R90.2 U6.12(0P1V)
N18496347: R92.2 U6.10(0P4V)
N18497261: R93.2 U6.8(1P6V)
N18499997: C116.1 U8.14(NR)
N18501914: R97.2 U8.8(1P6V)
N18501918: R95.2 U8.11(0P2V)
N18501920: R94.2 U8.12(0P1V)
N18501930: R96.2 U8.10(0P4V)
N18529139: J16.C18 R121.1
N18582117: C88.1 U5.12(LDOBYP2)
N18582124: C87.1 U5.11(LDOBYP1)
N18582340: D4.1(ANODE) R81.1
N18582465: R82.2 U5.59(CLKIN_SEL1)
N18582474: R81.2 U5.58(CLKIN_SEL0)
N63034531: C61.2 R66.1
N63036851: C62.2 R65.1
N169575690: C133.1 U11.15(SS)
N170006640: C136.1 U9.15(SS)
N172735392: Q4.3(C) R128.2
N172741842: Q2.3(C) R126.2

Pads without a net: J14 4; J15 6 7 8; J16 A2 A3 A6 A7 A10 A11 A14 A15 A18 A19 B1 B4 B5 B8 B9 B12 B13 B16 B17 B20 B21 B24 B25 B28 B29 B40 C6 C7 C10 C11 C19 C22 C23 C26 C27 C30 C31 C34 C35 C37 C39 D1 D20 D21 D23 D24 D26 D27 D29 D30 D31 D32 D33 D34 D35 D36 D38 D40 E2 E3 E6 E7 E9 E10 E12 E13 E15 E16 E18 E19 E21 E22 E24 E25 E27 E28 E30 E31 E33 E34 E36 E37 E39 F1 F4 F5 F7 F8 F13 F14 F16 F17 F22 F23 F25 F26 F28 F29 F31 F32 F34 F35 F37 F38 F40 G2 G3 G12 G13 G18 G19 G21 G22 G24 G25 G27 G28 G30 G31 G33 G34 G36 G37 G39 H1 H2 H4 H5 H7 H8 H10 H11 H13 H14 H19 H20 H22 H23 H25 H26 H28 H29 H31 H32 H34 H35 H37 H38 H40 J6 J7 J9 J10 J12 J13 J15 J16 J18 J19 J21 J22 J24 J25 J27 J28 J30 J31 J33 J34 J36 J37 J39 K1 K7 K8 K10 K11 K13 K14 K16 K17 K19 K20 K22 K23 K25 K26 K28 K29 K31 K32 K34 K35 K37 K38 K40; NOREF 1; NOREF#13 1; NOREF#24 1; NOREF#29 1; NOREF#41 1; NOREF#51 1; NOREF#52 1; NOREF#57 1; NOREF#64 1; NOREF#67 1; NOREF#68 1; NOREF#69 1; T1 2; T2 5; T3 2; T4 5; T5 2; T6 5; T7 2; T8 5; U1 12 14 30 38 39 47 48 49 50 62 64 66 67 83 84 85 86 87; U3 26 27 28 29 30 32 33 34 36 48 52 53 54 55 57 58 59 60; U4 7; U5 7 8 9 22 23 24 25 37 38 40 41 54 55 56 57 60 61; U6 2 4 5 6 9 17 18 19; U8 2 4 5 6 9 17 18 19; U9 9; U10 1 3; U11 9; U15 1

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 1424 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 221 vias
v3: diameter 0.305, hole 0.254, TOP to BOTTOM, 3 vias
v4: diameter 0.559, hole 0.305, TOP to BOTTOM, 1754 vias
v5: diameter 0.762, hole 0.381, TOP to BOTTOM, 80 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.8V_CPLD: length 30.8
  TOP w0.33: U1.45 v1(45.45,96.41) ; U1.31 v1(52.45,96.4) ; U1.63 v1(42.72,90.35) ; U1.9 v1(54.65,88.35) ; U1.13 v1(54.56,90.35)
  L3_PWR w0.254: J15.4 56.5,110.25 ; J15.4 54.75,112 ; J15.4 54.75,110.25 ; J15.4 56.5,112 ; JP3.1 45.11,113.31 ; JP3.1 45.11,111.48 ; JP3.1 43.28,111.48 ; JP3.1 43.28,113.31 ; 42.57,106.83 JP5.2 42.57,105
  L3_PWR w0.508: JP3.1 44.2,110.74 ; JP3.1 45.72,112.4 ; JP3.1 44.2,114.43 ; JP5.2 41.66,104.52 ; JP5.2 42.8,105.92 ; JP5.2 41.66,107.44
  vias: v1(48.01,115.95) v1(53.09,115.95)
1.8V_USB: length 15.8
  TOP w0.102: v1(31.24,100.33) 30.93,100.02 U3.49
  TOP w0.33: U3.12 v1(23.47,92.61) ; U3.64 v1(23.43,98.24) ; U3.37 v1(30.89,92.61)
  L3_PWR w0.254: JP5.3 40.03,106.83 ; JP5.3 40.03,105 ; JP5.3 38.2,105 ; JP5.3 38.2,106.83
  L3_PWR w0.508: JP5.3 37.72,105.92 ; JP5.3 39.12,107.57 ; JP5.3 39.12,104.39
  vias: v1(31.24,99.31) v1(32,100.71) v1(32,99.95) v1(32,99.31) v1(32.89,99.19) v1(33.02,99.95) v1(34.16,100.58) v1(34.16,99.19) v1(35.43,99.95)
3.3V: length 1.3
  BOTTOM w0.381: U6.3 v1(21.97,64.26)
  vias: v1(19.81,66.93) v1(20.32,68.07) v1(20.7,66.04) v1(20.96,67.31) v1(21.21,68.96) v1(21.84,68.2) v1(21.84,66.93) v1(21.84,66.04) v1(21.84,65.02) v1(21.84,63.12) v1(21.84,61.85) v1(21.84,60.58) v1(21.97,69.47) v1(22.61,66.8) v1(22.61,64.52) v1(22.73,67.69) v1(22.86,69.34) v1(23.11,66.04) v1(23.11,63.37) v1(23.11,62.36) v1(23.11,61.72) v1(23.11,61.09) v1(23.11,60.07) v1(23.5,68.58) v1(23.5,67.06) v1(23.5,64.64) v1(24.13,67.69) v1(24.26,69.34)
3.3V_CPLD: length 17.2
  TOP w0.254: R107.1 U15.5 v1(29.08,80.28) ; U1.59 v1(42.65,92.35) ; U1.80 v1(44.95,84.57) ; U1.94 v1(51.95,84.58)
  L3_PWR w0.254: 11.53,77.45 JP6.2 ; JP6.2 13.36,79.27 ; JP6.2 13.36,77.45 ; JP6.2 11.53,79.27
  L3_PWR w0.406: JP6.2 12.45,77.22 ; JP6.2 11.05,78.36 ; JP6.2 13.84,78.36
3.3V_USB: length 23.5
  TOP w0.33: v1(30.35,101.98) 30.43,101.91 U3.50 ; U3.31 v1(30.43,90.6) ; U3.42 v1(31,95.11) ; U3.56 v1(27.43,98.18) ; U3.20 v1(24.93,90.51)
  TOP w0.406: v1(8.51,104.65) v1(7.24,104.65) 7.29,104.7 U4.8 7.25,106.17 5.97,106.17 5.71,106.43 5.71,107.31 5.91,107.51 U4.6
  L3_PWR w0.254: 13.36,81.81 JP6.3 11.53,81.81
  L3_PWR w0.406: JP6.3 12.45,82.42 ; JP6.3 10.92,80.9 ; JP6.3 13.97,80.9
  vias: v1(7.62,87.5) v1(8.13,86.74) v1(9.02,87.5) v1(9.02,86.74) v1(10.16,89.79) v1(10.16,88.9) v1(10.92,89.53) v1(11.81,89.03) v1(14.48,105.92) v1(15.11,107.31) v1(24.77,116.71) v1(24.77,115.32) v1(24.77,113.92) v1(25.4,116.08) v1(25.4,114.68) v1(25.91,115.32) v1(26.42,116.08) v1(26.42,114.68) v1(26.67,112.65) v1(26.8,113.67) v1(26.8,111.63) v1(27.05,115.19) v1(27.18,116.59) v1(27.56,111.76) v1(27.69,112.9) v1(27.94,116.71) v1(27.94,115.7) v1(27.94,114.3) v1(28.45,114.94) v1(28.57,112.65) v1(28.52,111.63) v1(28.96,115.7) v1(28.96,114.3) v1(29.21,113.16) v1(29.34,116.71) v1(29.34,111.76) v1(29.72,102.36) v1(29.84,101.6) v1(30.86,102.36)
+0.9V_DAC: length 39.2
  TOP w0.508: FB18.1 v1(97.46,92.66) v1(96.32,92.66) v1(95.33,92.66)
  L3_PWR w0.254: TP21.1 166.74,87.61 ; TP21.1 164.23,87.61 ; TP21.1 164.23,85.11 ; TP21.1 166.74,85.11
  L6_PWR w0.254: TP21.1 166.74,87.61 ; TP21.1 164.23,85.11 ; TP21.1 164.23,87.61 ; TP21.1 166.74,85.11
  BOTTOM w0.254: TP21.1 166.74,87.61 ; TP21.1 164.23,87.61 ; TP21.1 164.23,85.11 ; TP21.1 166.74,85.11
  BOTTOM w0.508: FB19.1 C346.1
  BOTTOM w0.635: C346.1 C345.1 132.21,99.31 133.48,100.58
  BOTTOM w1.27: v1(132.59,108.59) v1(132.08,108.08) 132.08,106.81 133.48,105.41 133.48,100.58
  vias: v1(117.73,81.66) v1(117.73,81.03) v1(117.73,80.39) v1(163.58,87.88) v1(163.58,85.98) v1(163.7,84.07) v1(163.7,82.3) v1(163.7,80.52) v1(163.7,79.12) v1(163.7,77.72) v1(164.59,83.31) v1(164.72,81.28) v1(164.97,84.33) v1(165.2,82.3) v1(165.2,79.63) v1(165.2,77.85) v1(165.73,83.31) v1(165.73,81.28) v1(166.12,84.07) v1(167.13,84.33) v1(167.26,87.76) v1(169.8,83.44) v1(169.8,82.3) v1(169.8,81.28) v1(170.05,77.22) v1(170.05,76.33) v1(170.46,79.76) v1(170.46,78.23) v1(171.2,77.22) v1(171.2,76.33) v1(171.32,83.44) v1(171.32,82.3) v1(171.32,81.28) v1(171.45,78.11) v1(171.58,79.76) v1(172.34,78.87) v1(172.34,76.71) v1(172.47,77.85) v1(172.85,79.63) v1(173.61,78.74) v1(173.61,77.72) v1(174.21,76.61) v1(174.75,77.72)
+0.9V_VDDCLK: length 4.6
  TOP w0.254: v2(109.22,92.63) v2(108.42,92.63)
  TOP w0.508: C6.1 v1(100.36,92.66) v1(101.7,92.66) v1(102.82,92.66)
  vias: v1(106.43,92.71)
+0.9V_VDDDAC: length 8.3
  BOTTOM w0.508: v2(111.62,93.43) 111.65,93.4 C184.1 ; v1(125.35,99.31) v1(126.49,99.31) v1(127.38,99.31) v1(128.22,99.31) v1(128.22,100.08) 128.22,100.74 v1(128.14,100.81) ; v2(112.42,93.43) 112.45,93.4 C185.1 C186.1 C187.1 ; C183.1 C182.1
  vias: v1(123.82,94.36) v2(110.82,93.43) v2(113.22,93.43) v2(114.02,93.43) v2(114.82,93.43)
+0.9V_VDDDIG: length 24.3
  L3_PWR w0.254: 156.86,67.29 TP28.1 ; TP28.1 156.86,64.79 ; TP28.1 159.37,67.29 ; TP28.1 159.37,64.79
  L6_PWR w0.254: 156.86,64.79 TP28.1 ; TP28.1 159.37,64.79 ; TP28.1 156.86,67.29 ; TP28.1 159.37,67.29
  BOTTOM w0.102: v2(112.42,89.43) 112.42,89.58 C177.1 ; C180.1 111.25,88.32 111.25,88 111.24,87.99 111.24,87.67 111.25,87.66 111.25,87.12 ; v2(113.22,89.43) 113.22,89.55 C178.1 ; v2(114.02,89.43) 114.02,89.59 C179.1 ; v2(111.62,89.43) 111.63,89.44 C14.1
  BOTTOM w0.152: C175.1 110.95,86.82 111.25,87.12
  BOTTOM w0.254: TP28.1 159.37,67.29 ; TP28.1 156.86,64.79 ; TP28.1 156.86,67.29 ; TP28.1 159.37,64.79
  vias: v1(118.06,87.27) v1(118.01,86.46) v1(118.62,85.72) v1(118.74,87.3) v1(118.72,86.44) v1(118.74,83.82) v1(119.51,83.82) v1(120.45,83.82) v1(122.17,87) v1(122.17,85.72) v1(122.17,83.82) v1(160.4,66.55) v1(160.4,65.02) v1(161.32,65.94) v1(161.49,65.1) v1(162.18,66.52) v1(162.18,65.74) v1(162.26,64.85) v2(110.82,90.23) v2(110.82,89.43) v2(110.82,88.63) v2(114.82,91.83) v2(114.82,91.03) v2(114.82,90.23) v2(114.82,89.43) v2(116.08,86.16) v2(117.91,89.31)
+0.9V_VDDT: length 6.1
  TOP w0.381: v2(112.42,88.63) v2(113.22,88.63)
  BOTTOM w0.102: C5.1 113.6,87.36 113.6,88.33 113.3,88.63 v2(113.22,88.63) ; C4.1 112.8,87.33 112.8,88.37 112.54,88.63
  BOTTOM w0.254: v2(112.42,88.63) 112.54,88.63
  BOTTOM w0.381: 112.54,88.63 v2(113.22,88.63)
  BOTTOM w0.508: C4.1 C5.1
  vias: v1(119.13,81.66) v1(119.13,79.76) v1(119.25,80.77)
+1.8V_DAC: length 26.4
  L3_PWR w0.254: TP26.1 166.1,102.22 ; TP26.1 163.59,99.71 ; TP26.1 166.1,99.71 ; TP26.1 163.59,102.22
  BOTTOM w0.102: v1(125.78,92.2) R193.1
  BOTTOM w0.254: 163.59,102.22 TP26.1 ; TP26.1 163.59,99.71 ; TP26.1 166.1,102.22 ; TP26.1 166.1,99.71
  BOTTOM w0.508: v1(96.32,97.08) v1(97.21,97.08) v1(98.35,97.08) FB25.1 ; R193.1 125.98,92.33 v1(126.24,92.58) ; R194.1 v1(104.52,86.49) ; R194.1 v1(104.14,86.87) ; R194.1 v1(104.52,87.25) ; v1(125.73,91.57) 125.73,92.15 v1(125.78,92.2)
  BOTTOM w0.635: FB32.1 v1(109.83,110.92) v1(108.71,110.92) v1(107.82,110.92) ; FB29.1 v1(99.54,84.76) v1(99.54,83.64) v1(100.56,83.64)
  vias: v1(163.7,97.92) v1(163.7,96.65) v1(163.7,95.12) v1(163.7,93.85) v1(163.7,92.58) v1(163.83,90.81) v1(164.47,95.89) v1(164.85,94.49) v1(165.07,96.9) v1(165.07,92.46) v1(165.07,90.93) v1(165.23,93.6) v1(165.35,95.38) v1(169.8,97.92) v1(169.8,96.9) v1(169.8,95.76) v1(169.93,91.69) v1(170.33,94.36) v1(170.33,92.84) v1(170.94,97.92) v1(170.94,96.9) v1(170.94,95.76) v1(171.07,90.93) v1(171.45,94.23) v1(171.45,92.71) v1(172.21,91.31) v1(172.59,94.23) v1(172.59,92.46) v1(173.48,93.34) v1(173.74,92.33) v1(174.09,91.21) v1(175.13,92.33)
+1.8V_VDDAPLL: length 8.1
  TOP w0.254: v2(109.22,94.23) v2(109.22,93.43)
  BOTTOM w0.102: C25.1 109.22,94.31 v2(109.22,94.23)
  BOTTOM w0.381: v2(107.7,95.63) 107.7,94.62 107.95,94.36 108.41,94.36 C26.1 109.14,94.31 v2(109.22,94.23)
  BOTTOM w0.508: v1(102.92,97.08) v1(101.78,97.08) v1(100.43,97.08) v1(100.43,98.35) ; v2(109.22,93.43) v2(109.22,94.23)
  vias: v1(103.5,99.19)
+1.8V_VDDAREF: length 3.8
  BOTTOM w0.635: v1(114.45,110.92) v1(113.31,110.92) v1(111.96,110.92) v1(111.96,112.19)
  vias: v1(118.36,101.22) v2(110.02,94.23) v2(115.62,94.23)
+1.8V_VDDIO: length 19.7
  TOP w0.254: R63.1 v1(148.97,87.76)
  TOP w0.381: v2(115.62,91.83) v2(115.62,91.03)
  L6_PWR w0.406: 150.09,98.58 JP4.1 ; JP4.1 151.92,96.75 ; JP4.1 151.92,98.58 ; JP4.1 150.09,96.75 ; 153.77,98.58 JP1.1 ; JP1.1 153.77,96.75 ; JP1.1 155.6,96.75 ; JP1.1 155.6,98.58 ; 43.28,106.83 JP5.1 ; JP5.1 45.11,105 ; JP5.1 43.28,105 ; JP5.1 45.11,106.83
  BOTTOM w0.508: v2(123.82,91.44) v2(123.82,90.93) v2(123.82,90.42) C15.1 ; v1(124.84,91.57) 124.84,92.13 v1(124.92,92.2) 124.54,92.58 v1(124.46,92.58)
  vias: v1(137.03,89.53) v2(118.31,90.81) v2(119.58,90.73)
+1.8V_VDDR: length 7.2
  TOP w0.381: v2(112.42,87.83) v2(113.22,87.83)
  BOTTOM w0.254: v2(114.43,85.6) C33.1 C34.1
  BOTTOM w0.635: v1(99.54,89.15) v1(99.54,88.01) v1(99.54,86.66) ; v1(99.54,86.66) v1(98.25,86.66) ; v1(99.54,86.66) v1(100.96,86.66)
+1.8V_VDDS: length 0.8
  BOTTOM w0.381: v2(110.02,91.83) v2(110.02,91.03)
  vias: v2(105.54,86.87) v2(106.17,86.87) v2(106.17,86.36) v2(106.1,84.2) v2(106.43,85.47) v2(107.01,84.2)
+2.5V_LDO_IN: length 33.3
  L3_PWR w0.254: 175.28,64.15 TP20.1 ; TP20.1 175.28,66.66 ; TP20.1 177.78,64.15 ; TP20.1 177.78,66.66
  BOTTOM w0.254: 175.28,66.66 TP20.1 ; TP20.1 175.28,64.15 ; TP20.1 177.78,66.66 ; TP20.1 177.78,64.15
  BOTTOM w0.381: 172.91,83.24 172.91,84.77 v1(172.97,84.84) 173.23,85.09 v1(174.12,85.09) 174.14,85.09 174.21,85.16 ; 172.91,83.24 v1(172.85,83.19) ; 172.91,83.24 U9.5 ; 174.74,100.42 U11.7 ; 174.74,100.42 C126.1 175.39,99.8 U11.8 ; 174.74,100.42 174.09,99.77 ; 174.21,85.16 U9.6 ; 174.21,85.16 174.86,85.81 ; 174.09,99.77 174.02,99.69 v1(173.23,99.69) 173.1,99.69 172.78,99.37 v1(172.78,97.92) U11.5 ; 174.09,99.77 U11.6 ; U9.8 175.51,85.19 C135.1 174.86,85.81 ; U9.7 174.86,85.81
  vias: v1(172.34,98.43) v1(172.47,100.71) v1(172.47,99.82) v1(172.47,85.22) v1(172.59,83.95) v1(172.72,86.11) v1(172.85,98.81) v1(173.23,85.6) v1(173.48,98.17) v1(173.61,100.71) v1(173.61,99.06) v1(173.61,84.07) v1(173.86,86.11) v1(174.12,99.69) v1(174.5,66.93) v1(174.5,65.91) v1(174.5,64.9) v1(174.5,63.75) v1(174.75,100.46) v1(174.75,99.19) v1(174.88,85.85) v1(174.88,84.58) v1(175.26,63.75) v1(175.39,99.82) v1(175.39,67.06) v1(175.51,85.22) v1(175.64,86.11) v1(176.15,63.37) v1(176.15,57.15) v1(176.28,60.96) v1(176.4,61.59) v1(176.4,58.93) v1(176.56,62.48) v1(176.78,60.2) v1(176.78,57.91) v1(177.42,67.18) v1(177.42,62.61) v1(177.55,63.63) v1(177.55,61.72) v1(177.55,60.33) v1(177.55,58.29) v1(177.55,57.15) v1(177.93,98.3) v1(178.05,97.66) v1(178.05,83.19) v1(178.18,66.68) v1(178.56,83.69) v1(178.69,97.28) v1(178.69,67.18) v1(178.69,66.04) v1(178.69,64.9) v1(178.69,63.75) v1(178.82,98.04) v1(179.07,82.93) v1(179.32,83.69)
+3.3V_DAC: length 28
  L3_PWR w0.406: TP18.1 161.4,95.27 ; TP18.1 161.4,97.77 ; TP18.1 158.89,95.27 ; TP18.1 158.89,97.77
  L6_PWR w0.406: 158.89,97.77 TP18.1 ; TP18.1 161.4,97.77 ; TP18.1 161.4,95.27 ; TP18.1 158.89,95.27
  BOTTOM w0.381: U9.10 176.81,85.8 v1(176.78,85.83) ; U11.10 176.69,100.4 v1(176.66,100.43)
  BOTTOM w0.406: TP18.1 161.4,97.77 ; TP18.1 158.89,97.77 ; TP18.1 158.89,95.27 ; TP18.1 161.4,95.27
  BOTTOM w0.635: v1(130.48,104.55) v1(129.59,104.55) v1(128.45,104.55) FB33.1
  vias: v1(149.48,81.79) v1(149.99,82.55) v1(150.11,83.82) v1(150.88,83.19) v1(151.13,81.79) v1(151.64,83.82) v1(151.64,82.55) v1(152.27,81.79) v1(152.4,83.82) v1(152.4,82.8) v1(152.78,80.9) v1(152.78,79.76) v1(154.94,82.68) v1(155.07,81.41) v1(156.08,83.31) v1(156.08,82.42) v1(156.59,81.53) v1(156.97,82.55) v1(157.99,82.8) v1(157.99,81.53) v1(159.38,91.82) v1(159.38,88.14) v1(159.38,87.12) v1(159.38,83.31) v1(159.38,82.42) v1(159.51,94.62) v1(159.54,93.22) v1(159.51,89.66) v1(159.51,81.53) v1(159.77,90.42) v1(159.77,86.23) v1(159.89,91.31) v1(160.15,88.9) v1(160.15,82.68) v1(160.66,93.34) v1(160.66,92.2) v1(160.66,90.68) v1(160.66,85.72) v1(160.78,94.49) v1(160.78,89.66) v1(160.78,88.14) v1(160.78,83.19) v1(160.78,82.3) v1(160.91,87.12) v1(160.91,81.41)
+3.3V_VDDADAC: length 5.4
  TOP w0.381: v2(114.82,94.23) v2(114.02,94.23) ; v2(110.82,94.23) v2(111.62,94.23)
  BOTTOM w0.635: v1(124.05,104.55) v1(125.2,104.55) v1(126.54,104.55) v1(126.54,105.84)
  vias: v1(115.72,98.3)
+3.3VCLK: length 44.8
  TOP w0.508: v1(86.23,47.88) v1(86.23,46.36)
  L3_PWR w0.406: 36.97,59.58 TP17.1 ; TP17.1 39.48,59.58 ; TP17.1 39.48,62.09 ; TP17.1 36.97,62.09 ; JP6.1 13.36,74.91 ; JP6.1 14.22,75.82 ; JP6.1 11.05,75.82 ; JP6.1 11.53,74.91 ; JP6.1 12.45,73.66
  L3_PWR w1.27: v1(86.74,47.5) 87.91,46.33 87.91,38.94 88.77,38.07 88.77,35.81
  L6_PWR w0.406: TP17.1 39.48,62.09 ; TP17.1 36.97,62.09 ; TP17.1 39.48,59.58 ; TP17.1 36.97,59.58
  BOTTOM w0.254: v1(100.46,56.01) 100.46,56.16 100.23,56.39 FB9.1 ; C69.1 89.66,66.93 v1(90.3,66.29) ; C71.1 v1(100.84,54.61)
  BOTTOM w0.406: 36.97,59.58 TP17.1 ; TP17.1 39.48,62.09 ; TP17.1 39.48,59.58
  BOTTOM w0.508: C72.1 v1(76.96,56.01)
  vias: v1(25.65,61.34) v1(25.65,59.82) v1(26.16,60.58) v1(26.8,61.34) v1(26.92,59.82) v1(27.3,60.58) v1(27.69,109.86) v1(27.69,61.34) v1(27.81,110.62) v1(27.81,108.97) v1(27.81,59.94) v1(28.45,61.34) v1(28.45,60.07) v1(28.52,110.08) v1(28.57,108.97) v1(29.21,61.47) v1(29.21,60.71) v1(29.21,59.82) v1(29.46,110.62) v1(29.46,109.86) v1(29.46,108.97) v1(29.97,61.34) v1(29.97,60.07) v1(30.73,61.09) v1(31.12,59.94) v1(31.5,61.47) v1(31.5,60.58) v1(32.13,59.94) v1(32.26,60.96) v1(33.15,60.33) v1(33.53,61.34) v1(34.16,59.82) v1(34.29,60.83) v1(35.05,61.34) v1(35.18,60.33) v1(36.2,59.94) v1(36.45,61.47) v1(74.42,61.34) v1(75.06,60.45) v1(75.18,61.34) v1(76.58,58.55) v1(77.09,64.26) v1(77.34,65.66) v1(77.34,58.93) v1(77.6,63.5) v1(77.72,64.39) v1(77.72,58.42) v1(85.72,48.26) v1(85.72,47.5) v1(86.74,48.26) v1(90.42,66.93) v1(91.31,66.29) v1(92.33,49.78) v1(92.33,48.77) v1(92.71,49.28) v1(93.09,49.78) v1(93.09,48.77) v1(98.3,44.32) v1(98.3,39.62) v1(100.46,57.02) v1(117.91,40.71)
+5.0V: length 40.9
  TOP w0.254: TP19.1 173.97,70.47 ; TP19.1 171.47,70.47 ; TP19.1 173.97,67.96
  TOP w0.508: 172.47,69.22 170.56,69.22 ; 172.47,69.22 TP19.1 172.72,70.87 172.47,71.12 ; 172.47,69.22 171.2,70.49
  L3_PWR w0.254: TP19.1 173.97,67.96 ; TP19.1 171.47,67.96 ; TP19.1 171.47,70.47 ; TP19.1 173.97,70.47
  L6_PWR w0.254: TP19.1 173.97,67.96 ; TP19.1 173.97,70.47 ; TP19.1 171.47,67.96 ; TP19.1 171.47,70.47
  BOTTOM w0.254: U6.15 15.43,66.35 ; 171.47,70.47 TP19.1 ; TP19.1 173.97,70.47 ; TP19.1 173.97,67.96 ; TP19.1 171.47,67.96 ; v1(16.64,68.45) 16.73,68.36 U6.16 ; 152.43,76.42 v1(152.4,76.45) ; U6.13 v1(14.35,64.26)
  BOTTOM w0.305: v1(154.69,75.18) 154.75,75.12 ; 15.43,66.35 v1(15.49,66.42)
  BOTTOM w0.381: v1(154.69,75.18) 155.22,75.18 U8.15 ; U8.16 152.43,76.42 ; U8.15 v1(155.29,74.2) ; U8.15 154.75,75.12 ; U8.13 v1(156.59,74.17)
  vias: v1(13.21,67.69) v1(14.22,68.45) v1(14.22,67.69) v1(14.35,66.93) v1(14.35,66.17) v1(14.99,67.82) v1(15.37,68.45) v1(15.37,67.31) v1(16,67.95) v1(16.13,66.93) v1(29.21,44.32) v1(29.46,45.09) v1(29.46,43.56) v1(30.35,44.45) v1(30.73,45.21) v1(30.86,43.56) v1(31.76,45.09) v1(31.75,44.32) v1(32.38,43.56) v1(33.15,45.09) v1(33.15,44.2) v1(33.91,43.69) v1(34.16,44.83) v1(35.05,45.09) v1(35.05,44.07) v1(35.94,43.56) v1(36.07,44.96) v1(36.58,44.2) v1(36.96,45.09) v1(37.21,43.56) v1(37.85,45.09) v1(37.85,44.2) v1(152.78,75.69) v1(152.78,74.55) v1(152.78,73.53) v1(152.78,72.64) v1(169.67,74.55) v1(169.67,72.39) v1(170.27,73.53) v1(170.81,74.55) v1(170.81,72.39) v3(179.13,52.96) v3(179.13,49.28) v3(179.13,45.34)
+5V_IN: length 53.2
  L3_PWR w0.254: TP29.1 20.7,40.75 ; TP29.1 18.19,38.24 ; TP29.1 18.19,40.75 ; TP29.1 20.7,38.24 ; J23.1 15.62,48.62 ; J23.1 11.86,44.85 ; J23.1 11.86,48.62 ; J23.1 15.62,44.85
  L6_PWR w0.254: TP29.1 20.7,38.24 ; TP29.1 18.19,40.75 ; TP29.1 18.19,38.24 ; TP29.1 20.7,40.75 ; 11.86,44.85 J23.1 ; J23.1 15.62,48.62 ; J23.1 11.86,48.62 ; J23.1 15.62,44.85
  BOTTOM w0.254: TP29.1 20.7,38.24 ; TP29.1 18.19,40.75 ; TP29.1 20.7,40.75 ; TP29.1 18.19,38.24 ; J23.1 15.62,48.62 ; J23.1 15.62,44.85 ; J23.1 11.86,44.85 ; J23.1 11.86,48.62
  vias: v1(10.79,48.64) v1(10.79,47.5) v1(10.79,46.48) v1(10.79,45.34) v1(10.79,44.32) v1(10.79,43.18) v1(11.56,43.82) v1(11.68,49.02) v1(12.32,43.05) v1(12.83,49.66) v1(13.21,43.82) v1(13.34,51.94) v1(13.34,50.8) v1(14.1,43.05) v1(14.22,50.67) v1(14.35,49.66) v1(14.48,51.82) v1(14.99,43.82) v1(15.37,51.94) v1(15.37,49.66) v1(15.49,50.93) v1(15.75,43.05) v1(16,49.02) v1(16.13,44.96) v1(16.51,50.8) v1(16.51,48.51) v1(16.51,47.62) v1(16.64,49.78) v1(16.64,45.72) v1(16.64,43.43) v1(16.76,46.61) v1(17.14,41.53) v1(17.14,40.51) v1(17.14,39.5) v1(17.27,44.07) v1(17.27,38.74) v1(17.27,37.85) v1(17.4,45.59) v1(17.53,49.02) v1(17.53,47.75) v1(17.53,42.67) v1(17.78,46.74) v1(17.91,49.78) v1(18.29,44.83) v1(18.41,43.05) v1(18.41,37.72) v1(18.54,45.72) v1(18.54,43.94) v1(18.54,41.78) v1(19.43,44.96) v1(19.43,41.78) v1(19.68,42.93) v1(19.94,44.07) v1(20.19,45.72) v1(20.45,41.66) v1(20.83,37.85) v1(20.96,44.83) v1(21.08,43.31) v1(21.21,46.48) v1(21.97,45.85) v1(21.97,43.43) v1(22.35,44.83) v1(22.73,46.48) v1(23.11,43.31)
+5V_USB: length 25.3
  TOP w0.254: TP13.1 5.14,111.69 11.12,111.69 11.18,111.63
  TOP w0.508: v1(15.88,91.57) 15.88,90.81 17.27,89.41 17.27,86.61 13.46,82.8 R101.1
  vias: v1(9.52,111) v1(9.65,112.14) v1(10.29,111.25) v1(10.41,112.27) v1(11.05,112.01) v1(11.18,111) v1(11.81,111.63) v1(12.32,111) v1(12.7,112.14) v1(12.7,111.51) v1(13.44,112.14) v1(13.46,111.12) v1(13.74,96.77) v1(14.35,111.76) v1(14.35,111) v1(14.86,112.52) v1(15.24,111.76) v1(15.49,111) v1(15.88,112.01) v1(16.64,112.52) v1(16.64,111.76) v1(16.64,111) v1(17.65,112.52) v1(17.78,111.51) v1(18.67,112.4) v1(19.68,112.4)
GND: length 1834.2
  TOP w0.102: 166.88,16.79 166.85,16.76 ; 164.06,15.09 164.08,15.11 ; SJP1.3 116.3,39.14
  TOP w0.254: 33.42,108.82 TP6.1 ; TP6.1 35.93,108.82 ; TP6.1 33.42,106.31 ; TP6.1 35.93,106.31 ; J15.10 48.88,110.25 ; J15.10 47.13,112 ; J15.10 48.88,112 ; J15.10 47.13,110.25 ; J24.19 68.31,103.62 ; J24.19 66.56,103.62 ; J24.19 66.56,101.87 ; J24.19 68.31,101.87 ; 66.56,101.08 J24.17 ; J24.17 66.56,99.33 ; J24.17 68.31,99.33 ; J24.17 68.31,101.08 ; 15.76,76.09 SW2.1 ; SW2.1 18.1,76.09 ; SW2.1 18.1,73.75 ; SW2.1 15.76,73.75 ; SW2.2 17.8,82.3 ; SW2.2 16.05,80.54 ; SW2.2 16.05,82.3 ; SW2.2 17.8,80.54 ; J23.3 12.45,53.24 ; J23.3 9.04,49.83 ; J23.3 9.04,53.24 ; 1.92,103.39 TP22.1 ; TP22.1 4.43,105.9 ; TP22.1 4.43,103.39 ; TP22.1 1.92,105.9 ; TP7.1 73.39,73.04 ; TP7.1 70.88,73.04 ; TP7.1 73.39,75.55 ; TP7.1 70.88,75.55 ; 41.99,74.69 J25.7 ; J25.7 43.74,76.44 ; J25.7 41.99,76.44 ; J25.7 43.74,74.69 ; TP3.1 79.61,99.68 ; TP3.1 79.61,97.17 ; TP3.1 77.1,97.17 ; TP3.1 77.1,99.68 ; R131.2 115.82,99.69 ; J24.3 68.31,83.3 ; J24.3 66.56,83.3 ; J24.3 66.56,81.55 ; J24.3 68.31,81.55 ; 36.41,74.4 J25.1 36.41,76.73 ; J21.2 146.93,84.04 ; J21.2 145.17,82.28 ; J21.2 145.17,84.04 ; J21.2 146.93,82.28 ; 66.56,93.46 J24.11 ; J24.11 66.56,91.71 ; J24.11 68.31,93.46 ; J24.11 68.31,91.71 ; 160.04,42.78 TP4.1 162.54,40.27 ; 57.23,74.69 J25.19 57.23,76.44 ; 66.56,98.54 J24.15 ; J24.15 68.31,96.79 ; J24.15 68.31,98.54 ; J24.15 66.56,96.79 ; J25.9 46.28,74.69 ; J25.9 44.53,74.69 ; J25.9 44.53,76.44 ; J25.9 46.28,76.44 ; U2.H2 v2(114.82,87.83) ; J17.4 81.11,40.3 ; J17.4 78.66,42.76 ; J17.4 81.11,42.76 ; J17.4 78.66,40.3 ; TP5.1 39.48,53.74 ; TP5.1 36.97,53.74 ; TP5.1 39.48,56.25 ; TP5.1 36.97,56.25 ; 39.45,74.69 J25.5 ; J25.5 41.2,76.44 ; J25.5 39.45,76.44 ; J25.5 41.2,74.69 ; J17.3 81.11,37.68 ; J17.3 81.11,35.22 ; J17.3 78.66,37.68 ; J17.3 78.66,35.22 ; J17.2 86.19,37.68 ; J17.2 83.74,35.22 ; J17.2 86.19,35.22 ; J17.2 83.74,37.68 ; 52.15,74.69 J25.15 ; J25.15 52.15,76.44 ; J25.15 53.9,76.44 ; J25.15 53.9,74.69 ; 23.27,38.24 TP27.1 ; TP27.1 25.78,40.75 ; TP27.1 25.78,38.24 ; TP27.1 23.27,40.75 ; J24.5 68.31,84.09 ; J24.5 66.56,84.09 ; J24.5 66.56,85.84 ; J24.5 68.31,85.84 ; TP10.1 162.29,99.71 ; TP10.1 162.29,102.22 ; TP10.1 159.78,102.22 ; TP10.1 159.78,99.71 ; J25.17 56.44,76.44 ; J25.17 56.44,74.69 ; J25.17 54.69,74.69 ; J25.17 54.69,76.44 ; 36.91,76.44 J25.3 ; J25.3 38.66,74.69 ; J25.3 36.91,74.69 ; J25.3 38.66,76.44 ; 47.07,74.69 J25.11 ; J25.11 47.07,76.44 ; J25.11 48.82,76.44 ; J25.11 48.82,74.69 ; R114.2 106.17,97.28 ; 66.56,90.92 J24.9 ; J24.9 66.56,89.17 ; J24.9 68.31,90.92 ; J24.9 68.31,89.17 ; 83.74,40.3 J17.5 ; J17.5 83.74,42.76 ; J17.5 86.19,40.3 ; J17.5 86.19,42.76 ; 153.77,101.83 JP1.3 ; JP1.3 155.6,103.66 ; JP1.3 155.6,101.83 ; JP1.3 153.77,103.66 ; 128.16,84.6 TP12.1 ; TP12.1 128.16,87.11 ; TP12.1 130.67,84.6 ; TP12.1 130.67,87.11 ; 128.03,74.79 TP11.1 ; TP11.1 130.54,74.79 ; TP11.1 130.54,72.28 ; 66.56,96 J24.13 ; J24.13 68.31,94.25 ; J24.13 68.31,96 ; J24.13 66.56,94.25 ; J24.1 68.61,78.71 ; J24.1 68.61,81.05 ; J24.1 66.27,81.05 ; J24.1 66.27,78.71 ; R132.1 119.39,97.52 119.63,97.28 ; 51.95,99.44 v1(52.07,99.57) ; R117.1 107.73,99.1 v4(107.95,99.31) ; 151.78,92.44 TP8.1 ; TP8.1 154.29,92.44 ; TP8.1 151.78,89.93 ; TP8.1 154.29,89.93 ; R118.2 v1(112.78,99.69) R130.1 ; 5.79,45.03 J23.2 ; J23.2 9.2,45.03 ; J23.2 9.2,48.44 ; J23.2 5.79,48.44 ; J24.7 68.31,88.38 ; J24.7 66.56,88.38 ; J24.7 68.31,86.63 ; J24.7 66.56,86.63 ; 177.78,70.47 TP9.1 177.78,67.96 ; J25.13 51.36,76.44 ; J25.13 49.61,76.44 ; J25.13 49.61,74.69 ; J25.13 51.36,74.69 ; 150.09,103.66 JP4.3 151.92,103.66 ; U1.10 v1(58.47,88.85) ; 117.39,98.84 117.6,99.06 117.7,99.06 R134.2 ; JP3.3 40.03,113.31 ; JP3.3 40.03,111.48 ; JP3.3 38.2,113.31 ; JP3.3 38.2,111.48 ; 57.29,110.25 J15.2 58.17,109.96 ; R129.1 109.98,99.69 ; 146.93,74.66 J21.8 146.05,74.37 ; U1.11 v1(57.98,89.35) ; 146.93,81.5 J21.4 145.17,81.5 ; v1(113.54,100.58) 113.03,100.58 ; v1(17.65,95.76) 17.65,95.61 17.88,95.38 C51.2 ; C52.2 v1(18.16,93.85)
  TOP w0.33: U3.1 v1(21.55,98.77) ; U3.15 20.12,91.11 v1(19.94,90.93) ; U1.60 39.85,91.85 v1(39.62,92.08) ; U3.5 v1(22.96,96.11) ; U1.46 v1(44.95,99.43) ; U3.11 20.47,93.11 20.19,92.84 v1(19.94,92.84) ; v1(44.7,81.15) 44.45,81.41 U1.79 ; U1.1 v1(55.26,84.35) ; U3.25 v1(27.43,90.17) ; U3.35 v1(31.41,91.61) ; U3.51 v1(29.93,98.51) ; U1.65 v1(39.94,89.35) ; U1.93 v1(51.45,81.29) ; U3.10 v1(23.1,93.61) ; U3.13 22.7,92.11 v1(23.24,91.57) ; U1.32 51.95,99.44 ; U3.47 v1(31.29,97.61)
  TOP w0.381: v2(108.42,95.83) 108.26,95.83 ; v2(109.22,88.63) v2(109.22,87.83) v2(110.02,87.83) ; v2(109.22,88.63) v2(110.02,88.63) ; v2(109.22,88.63) v2(109.22,89.43) ; v2(109.22,89.43) v2(108.42,89.43) v2(108.42,90.23) ; v2(109.22,89.43) v2(109.22,90.23) ; v2(166.37,13.84) v1(165.1,15.11) 165.1,15.09 165.46,14.73 ; v2(112.42,95.03) v2(112.42,95.83) ; v2(112.42,95.03) v2(113.22,95.03) ; v2(112.42,95.03) v2(111.62,95.03) v2(110.82,95.03) v2(110.02,95.03) v2(109.22,95.03) U2.A11 ; v2(113.22,95.03) v2(113.22,95.83) ; v2(113.22,95.03) v2(114.02,95.03) v2(114.82,95.03) v2(115.62,95.03) v2(116.42,95.03) v2(117.22,95.03) v2(117.22,95.83) ; 166.85,16.76 v2(166.37,16.76) 165.73,17.4
  TOP w0.406: U4.5 v1(8.34,108.16)
  TOP w0.483: v1(145,112.12) 144.29,112.83 v1(144.29,112.84) ; v1(126.54,119) v1(127.55,119) ; v1(99.23,119) v1(98.21,119)
  TOP w0.508: v1(141.99,110.55) v1(142.71,109.83) ; 93.85,45.47 93.37,44.99 v1(93.33,44.99) ; v1(83.04,109.84) v1(83.76,110.56) ; 176.28,67.31 176.53,67.56 TP9.1 ; R6.1 104.39,90.04 v1(104.01,89.66) ; v1(81.48,112.87) v1(80.75,112.14) ; TP9.1 178.82,69.22 ; TP9.1 176.53,70.87 176.28,71.12 ; J14.5 v1(9.6,93.02) ; v1(126.54,115.77) v1(127.55,115.77) ; v1(98.21,115.77) v1(99.23,115.77) ; R112.1 104.27,94.62 v1(104.01,94.87) ; U15.3 v1(25.85,78.42)
  TOP w0.635: v4(170.81,44.58) Q4.2
  L2_GND w0.254: 49.61,76.44 J25.13 ; J25.13 51.36,74.69 ; J25.13 51.36,76.44 ; J25.13 49.61,74.69 ; 159.78,102.22 TP10.1 ; TP10.1 159.78,99.71 ; TP10.1 162.29,102.22 ; TP10.1 162.29,99.71 ; 66.56,84.09 J24.5 ; J24.5 68.31,85.84 ; J24.5 68.31,84.09 ; J24.5 66.56,85.84 ; 83.74,35.22 J17.2 ; J17.2 86.19,35.22 ; J17.2 83.74,37.68 ; J17.2 86.19,37.68 ; J25.15 53.9,74.69 ; J25.15 52.15,76.44 ; J25.15 53.9,76.44 ; J25.15 52.15,74.69 ; 57.29,112 J15.2 ; J15.2 59.04,112 ; J15.2 57.29,110.25 ; J15.2 59.04,110.25 ; J24.13 68.31,96 ; J24.13 66.56,94.25 ; J24.13 66.56,96 ; J24.13 68.31,94.25 ; 77.1,99.68 TP3.1 ; TP3.1 77.1,97.17 ; TP3.1 79.61,99.68 ; TP3.1 79.61,97.17 ; 66.56,93.46 J24.11 ; J24.11 68.31,91.71 ; J24.11 68.31,93.46 ; J24.11 66.56,91.71 ; 36.91,76.44 J25.3 ; J25.3 38.66,76.44 ; J25.3 36.91,74.69 ; J25.3 38.66,74.69 ; TP9.1 177.78,67.96 ; TP9.1 175.28,67.96 ; TP9.1 175.28,70.47 ; TP9.1 177.78,70.47 ; JP1.3 155.6,101.83 ; JP1.3 155.6,103.66 ; JP1.3 153.77,103.66 ; JP1.3 153.77,101.83 ; J24.17 68.31,101.08 ; J24.17 66.56,99.33 ; J24.17 66.56,101.08 ; J24.17 68.31,99.33 ; J25.7 43.74,74.69 ; J25.7 43.74,76.44 ; J25.7 41.99,76.44 ; J25.7 41.99,74.69 ; 66.56,101.87 J24.19 ; J24.19 66.56,103.62 ; J24.19 68.31,101.87 ; J24.19 68.31,103.62 ; J21.4 146.93,79.74 ; J21.4 145.17,81.5 ; J21.4 145.17,79.74 ; J21.4 146.93,81.5 ; J25.9 46.28,74.69 ; J25.9 44.53,74.69 ; J25.9 46.28,76.44 ; J25.9 44.53,76.44 ; TP5.1 39.48,56.25 ; TP5.1 36.97,53.74 ; TP5.1 39.48,53.74 ; TP5.1 36.97,56.25 ; 66.56,88.38 J24.7 ; J24.7 68.31,86.63 ; J24.7 66.56,86.63 ; J24.7 68.31,88.38 ; TP8.1 154.29,92.44 ; TP8.1 154.29,89.93 ; TP8.1 151.78,92.44 ; TP8.1 151.78,89.93 ; 78.66,37.68 J17.3 ; J17.3 78.66,35.22 ; J17.3 81.11,37.68 ; J17.3 81.11,35.22 ; J25.19 58.98,76.44 ; J25.19 58.98,74.69 ; J25.19 57.23,74.69 ; J25.19 57.23,76.44 ; J25.17 56.44,74.69 ; J25.17 54.69,76.44 ; J25.17 56.44,76.44 ; J25.17 54.69,74.69 ; 66.56,81.55 J24.3 ; J24.3 68.31,83.3 ; J24.3 66.56,83.3 ; J24.3 68.31,81.55 ; TP12.1 130.67,84.6 ; TP12.1 128.16,84.6 ; TP12.1 128.16,87.11 ; TP12.1 130.67,87.11 ; 83.74,42.76 J17.5 ; J17.5 86.19,40.3 ; J17.5 83.74,40.3 ; J17.5 86.19,42.76 ; 23.27,40.75 TP27.1 ; TP27.1 25.78,38.24 ; TP27.1 25.78,40.75 ; TP27.1 23.27,38.24 ; TP6.1 35.93,108.82 ; TP6.1 35.93,106.31 ; TP6.1 33.42,106.31 ; TP6.1 33.42,108.82 ; 47.13,112 J15.10 ; J15.10 47.13,110.25 ; J15.10 48.88,112 ; J15.10 48.88,110.25 ; J21.6 146.93,78.96 ; J21.6 146.93,77.2 ; J21.6 145.17,78.96 ; J21.6 145.17,77.2 ; TP22.1 4.43,103.39 ; TP22.1 1.92,103.39 ; TP22.1 4.43,105.9 ; TP22.1 1.92,105.9 ; J21.2 146.93,84.04 ; J21.2 145.17,84.04 ; J21.2 145.17,82.28 ; J21.2 146.93,82.28 ; TP4.1 162.54,42.78 ; TP4.1 160.04,40.27 ; TP4.1 162.54,40.27 ; TP4.1 160.04,42.78 ; J21.8 146.93,76.42 ; J21.8 145.17,74.66 ; J21.8 146.93,74.66 ; J21.8 145.17,76.42 ; TP11.1 130.54,72.28 ; TP11.1 130.54,74.79 ; TP11.1 128.03,74.79 ; TP11.1 128.03,72.28 ; JP3.3 40.03,113.31 ; JP3.3 40.03,111.48 ; JP3.3 38.2,111.48 ; JP3.3 38.2,113.31 ; 150.09,101.83 JP4.3 ; JP4.3 151.92,101.83 ; JP4.3 150.09,103.66 ; JP4.3 151.92,103.66 ; 16.05,82.3 SW2.2 ; SW2.2 17.8,82.3 ; SW2.2 16.05,80.54 ; SW2.2 17.8,80.54 ; 70.88,73.04 TP7.1 ; TP7.1 73.39,73.04 ; TP7.1 73.39,75.55 ; TP7.1 70.88,75.55 ; J24.1 68.31,80.76 ; J24.1 68.31,79.01 ; J24.1 66.56,80.76 ; J24.1 66.56,79.01 ; J23.2 9.2,48.44 ; J23.2 5.79,48.44 ; J23.2 9.2,45.03 ; J23.2 5.79,45.03 ; J24.9 68.31,89.17 ; J24.9 66.56,90.92 ; J24.9 68.31,90.92 ; J24.9 66.56,89.17 ; J24.15 68.31,96.79 ; J24.15 66.56,96.79 ; J24.15 68.31,98.54 ; J24.15 66.56,98.54 ; J25.11 48.82,76.44 ; J25.11 47.07,76.44 ; J25.11 48.82,74.69 ; J25.11 47.07,74.69 ; 78.66,40.3 J17.4 ; J17.4 78.66,42.76 ; J17.4 81.11,40.3 ; J17.4 81.11,42.76 ; J23.3 12.45,53.24 ; J23.3 9.04,53.24 ; J23.3 9.04,49.83 ; 39.45,76.44 J25.5 ; J25.5 39.45,74.69 ; J25.5 41.2,74.69 ; J25.5 41.2,76.44 ; SW2.1 17.8,74.04 ; SW2.1 16.05,75.8 ; SW2.1 17.8,75.8 ; SW2.1 16.05,74.04 ; 34.37,74.69 J25.1 ; J25.1 34.37,76.44 ; J25.1 36.12,74.69 ; J25.1 36.12,76.44
  L2_GND w0.305: 116.33,73.23 116.33,72.9 116.08,72.64
  L3_PWR w0.254: 160.04,40.27 TP4.1 ; TP4.1 162.54,42.78 ; TP4.1 160.04,42.78 ; TP4.1 162.54,40.27
  L4_GND w0.254: 39.45,76.44 J25.5 ; J25.5 41.2,76.44 ; J25.5 41.2,74.69 ; J25.5 39.45,74.69 ; J15.2 59.04,112 ; J15.2 57.29,112 ; J15.2 57.29,110.25 ; J15.2 59.04,110.25 ; J17.3 81.11,35.22 ; J17.3 78.66,37.68 ; J17.3 81.11,37.68 ; J17.3 78.66,35.22 ; 66.56,90.92 J24.9 ; J24.9 68.31,89.17 ; J24.9 66.56,89.17 ; J24.9 68.31,90.92 ; 145.17,78.96 J21.6 ; J21.6 146.93,77.2 ; J21.6 145.17,77.2 ; J21.6 146.93,78.96 ; 175.28,70.47 TP9.1 ; TP9.1 177.78,70.47 ; TP9.1 177.78,67.96 ; TP9.1 175.28,67.96 ; 66.56,101.08 J24.17 ; J24.17 66.56,99.33 ; J24.17 68.31,99.33 ; J24.17 68.31,101.08 ; 159.78,99.71 TP10.1 ; TP10.1 162.29,102.22 ; TP10.1 159.78,102.22 ; TP10.1 162.29,99.71 ; J24.3 68.31,81.55 ; J24.3 68.31,83.3 ; J24.3 66.56,81.55 ; J24.3 66.56,83.3 ; TP3.1 79.61,97.17 ; TP3.1 77.1,99.68 ; TP3.1 79.61,99.68 ; TP3.1 77.1,97.17 ; SW2.1 17.8,75.8 ; SW2.1 16.05,75.8 ; SW2.1 17.8,74.04 ; SW2.1 16.05,74.04 ; J21.4 146.93,79.74 ; J21.4 146.93,81.5 ; J21.4 145.17,79.74 ; J21.4 145.17,81.5 ; J24.7 68.31,86.63 ; J24.7 66.56,86.63 ; J24.7 66.56,88.38 ; J24.7 68.31,88.38 ; 78.66,40.3 J17.4 ; J17.4 78.66,42.76 ; J17.4 81.11,40.3 ; J17.4 81.11,42.76 ; J17.2 86.19,37.68 ; J17.2 83.74,35.22 ; J17.2 83.74,37.68 ; J17.2 86.19,35.22 ; 151.78,92.44 TP8.1 ; TP8.1 154.29,92.44 ; TP8.1 151.78,89.93 ; TP8.1 154.29,89.93 ; 44.53,76.44 J25.9 ; J25.9 46.28,74.69 ; J25.9 46.28,76.44 ; J25.9 44.53,74.69 ; 128.16,87.11 TP12.1 ; TP12.1 130.67,84.6 ; TP12.1 128.16,84.6 ; TP12.1 130.67,87.11 ; 66.56,91.71 J24.11 ; J24.11 68.31,91.71 ; J24.11 66.56,93.46 ; J24.11 68.31,93.46 ; TP27.1 25.78,40.75 ; TP27.1 23.27,38.24 ; TP27.1 25.78,38.24 ; TP27.1 23.27,40.75 ; J25.13 51.36,74.69 ; J25.13 49.61,76.44 ; J25.13 51.36,76.44 ; J25.13 49.61,74.69 ; 1.92,105.9 TP22.1 ; TP22.1 4.43,105.9 ; TP22.1 4.43,103.39 ; TP22.1 1.92,103.39 ; 54.69,74.69 J25.17 ; J25.17 56.44,76.44 ; J25.17 56.44,74.69 ; J25.17 54.69,76.44 ; 36.97,53.74 TP5.1 ; TP5.1 39.48,56.25 ; TP5.1 36.97,56.25 ; TP5.1 39.48,53.74 ; 33.42,106.31 TP6.1 ; TP6.1 35.93,108.82 ; TP6.1 33.42,108.82 ; TP6.1 35.93,106.31 ; J24.19 68.31,103.62 ; J24.19 66.56,101.87 ; J24.19 68.31,101.87 ; J24.19 66.56,103.62 ; J25.19 58.98,76.44 ; J25.19 58.98,74.69 ; J25.19 57.23,74.69 ; J25.19 57.23,76.44 ; TP7.1 73.39,73.04 ; TP7.1 70.88,73.04 ; TP7.1 73.39,75.55 ; TP7.1 70.88,75.55 ; TP4.1 162.54,40.27 ; TP4.1 160.04,40.27 ; TP4.1 162.54,42.78 ; TP4.1 160.04,42.78 ; SW2.2 17.8,82.3 ; SW2.2 16.05,82.3 ; SW2.2 16.05,80.54 ; SW2.2 17.8,80.54 ; JP4.3 151.92,101.83 ; JP4.3 150.09,101.83 ; JP4.3 150.09,103.66 ; JP4.3 151.92,103.66 ; J25.1 36.12,76.44 ; J25.1 34.37,76.44 ; J25.1 36.12,74.69 ; J25.1 34.37,74.69 ; 128.03,74.79 TP11.1 ; TP11.1 130.54,72.28 ; TP11.1 128.03,72.28 ; TP11.1 130.54,74.79 ; 83.74,42.76 J17.5 ; J17.5 83.74,40.3 ; J17.5 86.19,40.3 ; J17.5 86.19,42.76 ; 66.56,96.79 J24.15 ; J24.15 68.31,98.54 ; J24.15 66.56,98.54 ; J24.15 68.31,96.79 ; J24.1 68.31,80.76 ; J24.1 68.31,79.01 ; J24.1 66.56,79.01 ; J24.1 66.56,80.76 ; 66.56,84.09 J24.5 ; J24.5 66.56,85.84 ; J24.5 68.31,85.84 ; J24.5 68.31,84.09 ; 52.15,76.44 J25.15 ; J25.15 52.15,74.69 ; J25.15 53.9,74.69 ; J25.15 53.9,76.44 ; 153.77,101.83 JP1.3 ; JP1.3 155.6,101.83 ; JP1.3 153.77,103.66 ; JP1.3 155.6,103.66 ; 38.2,111.48 JP3.3 ; JP3.3 40.03,113.31 ; JP3.3 40.03,111.48 ; JP3.3 38.2,113.31 ; J24.13 68.31,96 ; J24.13 68.31,94.25 ; J24.13 66.56,94.25 ; J24.13 66.56,96 ; J23.2 9.2,45.03 ; J23.2 5.79,45.03 ; J23.2 9.2,48.44 ; J23.2 5.79,48.44 ; J25.11 48.82,74.69 ; J25.11 48.82,76.44 ; J25.11 47.07,76.44 ; J25.11 47.07,74.69 ; 41.99,74.69 J25.7 ; J25.7 43.74,76.44 ; J25.7 43.74,74.69 ; J25.7 41.99,76.44 ; J25.3 38.66,74.69 ; J25.3 36.91,74.69 ; J25.3 38.66,76.44 ; J25.3 36.91,76.44 ; 47.13,112 J15.10 ; J15.10 47.13,110.25 ; J15.10 48.88,110.25 ; J15.10 48.88,112 ; J21.2 146.93,82.28 ; J21.2 145.17,84.04 ; J21.2 146.93,84.04 ; J21.2 145.17,82.28 ; 145.17,74.66 J21.8 ; J21.8 146.93,76.42 ; J21.8 146.93,74.66 ; J21.8 145.17,76.42 ; 9.04,49.83 J23.3 ; J23.3 9.04,53.24 ; J23.3 12.45,53.24
  L5_GND w0.254: J25.5 41.2,74.69 ; J25.5 39.45,76.44 ; J25.5 41.2,76.44 ; J25.5 39.45,74.69 ; 66.56,88.38 J24.7 ; J24.7 66.56,86.63 ; J24.7 68.31,86.63 ; J24.7 68.31,88.38 ; J15.2 59.04,112 ; J15.2 57.29,110.25 ; J15.2 59.04,110.25 ; J15.2 57.29,112 ; 145.17,84.04 J21.2 ; J21.2 146.93,82.28 ; J21.2 146.93,84.04 ; J21.2 145.17,82.28 ; TP12.1 130.67,87.11 ; TP12.1 128.16,84.6 ; TP12.1 130.67,84.6 ; TP12.1 128.16,87.11 ; 78.66,40.3 J17.4 ; J17.4 81.11,42.76 ; J17.4 78.66,42.76 ; J17.4 81.11,40.3 ; 5.79,45.03 J23.2 ; J23.2 9.2,45.03 ; J23.2 9.2,48.44 ; J23.2 5.79,48.44 ; J24.9 68.31,90.92 ; J24.9 68.31,89.17 ; J24.9 66.56,90.92 ; J24.9 66.56,89.17 ; 9.04,53.24 J23.3 ; J23.3 9.04,49.83 ; J23.3 12.45,53.24 ; JP4.3 151.92,103.66 ; JP4.3 150.09,103.66 ; JP4.3 150.09,101.83 ; JP4.3 151.92,101.83 ; J25.15 53.9,76.44 ; J25.15 53.9,74.69 ; J25.15 52.15,74.69 ; J25.15 52.15,76.44 ; 33.42,106.31 TP6.1 ; TP6.1 35.93,106.31 ; TP6.1 33.42,108.82 ; TP6.1 35.93,108.82 ; 145.17,81.5 J21.4 ; J21.4 146.93,81.5 ; J21.4 145.17,79.74 ; J21.4 146.93,79.74 ; J25.11 48.82,76.44 ; J25.11 48.82,74.69 ; J25.11 47.07,74.69 ; J25.11 47.07,76.44 ; 83.74,42.76 J17.5 ; J17.5 86.19,40.3 ; J17.5 83.74,40.3 ; J17.5 86.19,42.76 ; J24.17 68.31,99.33 ; J24.17 68.31,101.08 ; J24.17 66.56,99.33 ; J24.17 66.56,101.08 ; 66.56,94.25 J24.13 ; J24.13 66.56,96 ; J24.13 68.31,94.25 ; J24.13 68.31,96 ; 36.97,53.74 TP5.1 ; TP5.1 36.97,56.25 ; TP5.1 39.48,56.25 ; TP5.1 39.48,53.74 ; 78.66,37.68 J17.3 ; J17.3 81.11,35.22 ; J17.3 81.11,37.68 ; J17.3 78.66,35.22 ; J24.11 68.31,93.46 ; J24.11 66.56,91.71 ; J24.11 66.56,93.46 ; J24.11 68.31,91.71 ; 54.69,74.69 J25.17 ; J25.17 56.44,76.44 ; J25.17 56.44,74.69 ; J25.17 54.69,76.44 ; 160.04,42.78 TP4.1 ; TP4.1 162.54,42.78 ; TP4.1 160.04,40.27 ; TP4.1 162.54,40.27 ; 34.37,76.44 J25.1 ; J25.1 36.12,74.69 ; J25.1 36.12,76.44 ; J25.1 34.37,74.69 ; 66.56,84.09 J24.5 ; J24.5 68.31,84.09 ; J24.5 66.56,85.84 ; J24.5 68.31,85.84 ; 57.23,74.69 J25.19 ; J25.19 58.98,74.69 ; J25.19 57.23,76.44 ; J25.19 58.98,76.44 ; 66.56,103.62 J24.19 ; J24.19 66.56,101.87 ; J24.19 68.31,101.87 ; J24.19 68.31,103.62 ; 77.1,99.68 TP3.1 ; TP3.1 79.61,97.17 ; TP3.1 77.1,97.17 ; TP3.1 79.61,99.68 ; 83.74,35.22 J17.2 ; J17.2 83.74,37.68 ; J17.2 86.19,37.68 ; J17.2 86.19,35.22 ; 49.61,76.44 J25.13 ; J25.13 49.61,74.69 ; J25.13 51.36,76.44 ; J25.13 51.36,74.69 ; 66.56,81.55 J24.3 ; J24.3 68.31,81.55 ; J24.3 68.31,83.3 ; J24.3 66.56,83.3 ; 145.17,78.96 J21.6 ; J21.6 146.93,78.96 ; J21.6 145.17,77.2 ; J21.6 146.93,77.2 ; 47.13,112 J15.10 ; J15.10 48.88,112 ; J15.10 47.13,110.25 ; J15.10 48.88,110.25 ; 41.99,76.44 J25.7 ; J25.7 41.99,74.69 ; J25.7 43.74,76.44 ; J25.7 43.74,74.69 ; SW2.2 17.8,82.3 ; SW2.2 16.05,80.54 ; SW2.2 17.8,80.54 ; SW2.2 16.05,82.3 ; TP9.1 177.78,67.96 ; TP9.1 175.28,67.96 ; TP9.1 177.78,70.47 ; TP9.1 175.28,70.47 ; 23.27,38.24 TP27.1 ; TP27.1 25.78,38.24 ; TP27.1 25.78,40.75 ; TP27.1 23.27,40.75 ; TP7.1 73.39,73.04 ; TP7.1 73.39,75.55 ; TP7.1 70.88,73.04 ; TP7.1 70.88,75.55 ; 38.2,111.48 JP3.3 ; JP3.3 38.2,113.31 ; JP3.3 40.03,111.48 ; JP3.3 40.03,113.31 ; 44.53,74.69 J25.9 ; J25.9 46.28,76.44 ; J25.9 46.28,74.69 ; J25.9 44.53,76.44 ; TP11.1 130.54,74.79 ; TP11.1 128.03,74.79 ; TP11.1 128.03,72.28 ; TP11.1 130.54,72.28 ; J25.3 38.66,74.69 ; J25.3 36.91,76.44 ; J25.3 36.91,74.69 ; J25.3 38.66,76.44 ; J21.8 146.93,74.66 ; J21.8 145.17,74.66 ; J21.8 146.93,76.42 ; J21.8 145.17,76.42 ; 1.92,103.39 TP22.1 ; TP22.1 4.43,105.9 ; TP22.1 1.92,105.9 ; TP22.1 4.43,103.39 ; J24.15 68.31,96.79 ; J24.15 68.31,98.54 ; J24.15 66.56,98.54 ; J24.15 66.56,96.79 ; JP1.3 155.6,103.66 ; JP1.3 153.77,103.66 ; JP1.3 153.77,101.83 ; JP1.3 155.6,101.83 ; TP10.1 162.29,99.71 ; TP10.1 159.78,99.71 ; TP10.1 162.29,102.22 ; TP10.1 159.78,102.22 ; 66.56,79.01 J24.1 ; J24.1 68.31,79.01 ; J24.1 68.31,80.76 ; J24.1 66.56,80.76 ; TP8.1 154.29,92.44 ; TP8.1 151.78,92.44 ; TP8.1 154.29,89.93 ; TP8.1 151.78,89.93 ; 16.05,75.8 SW2.1 ; SW2.1 17.8,74.04 ; SW2.1 17.8,75.8 ; SW2.1 16.05,74.04
  L7_GND w0.254: TP4.1 162.54,42.78 ; TP4.1 160.04,40.27 ; TP4.1 162.54,40.27 ; TP4.1 160.04,42.78 ; 9.04,49.83 J23.3 ; J23.3 12.45,53.24 ; J23.3 9.04,53.24 ; J25.13 51.36,76.44 ; J25.13 51.36,74.69 ; J25.13 49.61,76.44 ; J25.13 49.61,74.69 ; 66.56,93.46 J24.11 ; J24.11 68.31,93.46 ; J24.11 66.56,91.71 ; J24.11 68.31,91.71 ; 145.17,78.96 J21.6 ; J21.6 146.93,78.96 ; J21.6 145.17,77.2 ; J21.6 146.93,77.2 ; J24.1 68.31,79.01 ; J24.1 68.31,80.76 ; J24.1 66.56,79.01 ; J24.1 66.56,80.76 ; SW2.2 17.8,80.54 ; SW2.2 16.05,80.54 ; SW2.2 16.05,82.3 ; SW2.2 17.8,82.3 ; 66.56,88.38 J24.7 ; J24.7 66.56,86.63 ; J24.7 68.31,88.38 ; J24.7 68.31,86.63 ; 145.17,84.04 J21.2 ; J21.2 146.93,84.04 ; J21.2 145.17,82.28 ; J21.2 146.93,82.28 ; J24.17 68.31,99.33 ; J24.17 68.31,101.08 ; J24.17 66.56,99.33 ; J24.17 66.56,101.08 ; 83.74,40.3 J17.5 ; J17.5 86.19,40.3 ; J17.5 86.19,42.76 ; J17.5 83.74,42.76 ; J25.5 41.2,76.44 ; J25.5 41.2,74.69 ; J25.5 39.45,76.44 ; J25.5 39.45,74.69 ; 153.77,101.83 JP1.3 ; JP1.3 153.77,103.66 ; JP1.3 155.6,101.83 ; JP1.3 155.6,103.66 ; 44.53,76.44 J25.9 ; J25.9 46.28,76.44 ; J25.9 44.53,74.69 ; J25.9 46.28,74.69 ; TP7.1 73.39,75.55 ; TP7.1 70.88,75.55 ; TP7.1 70.88,73.04 ; TP7.1 73.39,73.04 ; J21.4 146.93,81.5 ; J21.4 145.17,81.5 ; J21.4 145.17,79.74 ; J21.4 146.93,79.74 ; TP5.1 39.48,56.25 ; TP5.1 39.48,53.74 ; TP5.1 36.97,56.25 ; TP5.1 36.97,53.74 ; 175.28,67.96 TP9.1 ; TP9.1 175.28,70.47 ; TP9.1 177.78,67.96 ; TP9.1 177.78,70.47 ; 66.56,81.55 J24.3 ; J24.3 66.56,83.3 ; J24.3 68.31,83.3 ; J24.3 68.31,81.55 ; TP6.1 35.93,106.31 ; TP6.1 35.93,108.82 ; TP6.1 33.42,108.82 ; TP6.1 33.42,106.31 ; JP4.3 151.92,103.66 ; JP4.3 151.92,101.83 ; JP4.3 150.09,103.66 ; JP4.3 150.09,101.83 ; J24.13 68.31,94.25 ; J24.13 66.56,96 ; J24.13 68.31,96 ; J24.13 66.56,94.25 ; TP22.1 4.43,103.39 ; TP22.1 4.43,105.9 ; TP22.1 1.92,103.39 ; TP22.1 1.92,105.9 ; J15.10 48.88,110.25 ; J15.10 47.13,110.25 ; J15.10 48.88,112 ; J15.10 47.13,112 ; J25.1 36.12,74.69 ; J25.1 34.37,76.44 ; J25.1 36.12,76.44 ; J25.1 34.37,74.69 ; J24.15 68.31,96.79 ; J24.15 68.31,98.54 ; J24.15 66.56,96.79 ; J24.15 66.56,98.54 ; 77.1,97.17 TP3.1 ; TP3.1 79.61,99.68 ; TP3.1 77.1,99.68 ; TP3.1 79.61,97.17 ; 151.78,89.93 TP8.1 ; TP8.1 154.29,92.44 ; TP8.1 151.78,92.44 ; TP8.1 154.29,89.93 ; 128.03,74.79 TP11.1 ; TP11.1 130.54,72.28 ; TP11.1 130.54,74.79 ; TP11.1 128.03,72.28 ; 159.78,99.71 TP10.1 ; TP10.1 162.29,99.71 ; TP10.1 159.78,102.22 ; TP10.1 162.29,102.22 ; TP12.1 130.67,87.11 ; TP12.1 130.67,84.6 ; TP12.1 128.16,84.6 ; TP12.1 128.16,87.11 ; J25.3 38.66,76.44 ; J25.3 38.66,74.69 ; J25.3 36.91,74.69 ; J25.3 36.91,76.44 ; 145.17,76.42 J21.8 ; J21.8 145.17,74.66 ; J21.8 146.93,76.42 ; J21.8 146.93,74.66 ; J24.9 68.31,90.92 ; J24.9 66.56,89.17 ; J24.9 68.31,89.17 ; J24.9 66.56,90.92 ; 66.56,101.87 J24.19 ; J24.19 66.56,103.62 ; J24.19 68.31,101.87 ; J24.19 68.31,103.62 ; J17.4 81.11,42.76 ; J17.4 78.66,40.3 ; J17.4 81.11,40.3 ; J17.4 78.66,42.76 ; 52.15,74.69 J25.15 ; J25.15 52.15,76.44 ; J25.15 53.9,74.69 ; J25.15 53.9,76.44 ; 78.66,35.22 J17.3 ; J17.3 78.66,37.68 ; J17.3 81.11,37.68 ; J17.3 81.11,35.22 ; J24.5 68.31,84.09 ; J24.5 66.56,85.84 ; J24.5 68.31,85.84 ; J24.5 66.56,84.09 ; 16.05,74.04 SW2.1 ; SW2.1 17.8,74.04 ; SW2.1 17.8,75.8 ; SW2.1 16.05,75.8 ; 5.79,45.03 J23.2 ; J23.2 5.79,48.44 ; J23.2 9.2,48.44 ; J23.2 9.2,45.03 ; J25.17 56.44,74.69 ; J25.17 56.44,76.44 ; J25.17 54.69,76.44 ; J25.17 54.69,74.69 ; J17.2 86.19,35.22 ; J17.2 86.19,37.68 ; J17.2 83.74,35.22 ; J17.2 83.74,37.68 ; J25.11 48.82,76.44 ; J25.11 47.07,76.44 ; J25.11 47.07,74.69 ; J25.11 48.82,74.69 ; J25.19 58.98,76.44 ; J25.19 58.98,74.69 ; J25.19 57.23,76.44 ; J25.19 57.23,74.69 ; 23.27,40.75 TP27.1 ; TP27.1 25.78,38.24 ; TP27.1 25.78,40.75 ; TP27.1 23.27,38.24 ; JP3.3 40.03,113.31 ; JP3.3 38.2,111.48 ; JP3.3 40.03,111.48 ; JP3.3 38.2,113.31 ; J25.7 43.74,74.69 ; J25.7 41.99,74.69 ; J25.7 41.99,76.44 ; J25.7 43.74,76.44 ; J15.2 59.04,110.25 ; J15.2 57.29,112 ; J15.2 57.29,110.25 ; J15.2 59.04,112
  BOTTOM w0.254: 78.66,40.3 J17.4 ; J17.4 78.66,42.76 ; J17.4 81.11,42.76 ; J17.4 81.11,40.3 ; 150.09,101.83 JP4.3 ; JP4.3 151.92,101.83 ; JP4.3 150.09,103.66 ; JP4.3 151.92,103.66 ; 145.17,79.74 J21.4 ; J21.4 146.93,81.5 ; J21.4 146.93,79.74 ; J21.4 145.17,81.5 ; 66.56,89.17 J24.9 ; J24.9 68.31,89.17 ; J24.9 66.56,90.92 ; J24.9 68.31,90.92 ; 159.78,99.71 TP10.1 ; TP10.1 162.29,99.71 ; TP10.1 159.78,102.22 ; TP10.1 162.29,102.22 ; 66.56,83.3 J24.3 ; J24.3 66.56,81.55 ; J24.3 68.31,83.3 ; J24.3 68.31,81.55 ; TP11.1 130.54,74.79 ; TP11.1 128.03,74.79 ; TP11.1 128.03,72.28 ; TP11.1 130.54,72.28 ; 23.27,38.24 TP27.1 ; TP27.1 23.27,40.75 ; TP27.1 25.78,38.24 ; TP27.1 25.78,40.75 ; TP8.1 154.29,89.93 ; TP8.1 154.29,92.44 ; TP8.1 151.78,89.93 ; TP8.1 151.78,92.44 ; J23.3 12.45,53.24 ; J23.3 9.04,49.83 ; J23.3 9.04,53.24 ; 54.69,74.69 J25.17 ; J25.17 54.69,76.44 ; J25.17 56.44,74.69 ; J25.17 56.44,76.44 ; 160.04,40.27 TP4.1 ; TP4.1 162.54,42.78 ; TP4.1 160.04,42.78 ; TP4.1 162.54,40.27 ; TP22.1 4.43,103.39 ; TP22.1 1.92,105.9 ; TP22.1 4.43,105.9 ; TP22.1 1.92,103.39 ; C180.2 110.87,87.88 v2(110.82,87.83) 110.87,87.78 C175.2 ; 16.05,80.54 SW2.2 ; SW2.2 17.8,82.3 ; SW2.2 17.8,80.54 ; SW2.2 16.05,82.3 ; 83.74,37.68 J17.2 ; J17.2 83.74,35.22 ; J17.2 86.19,35.22 ; J17.2 86.19,37.68 ; 66.56,96.79 J24.15 ; J24.15 68.31,96.79 ; J24.15 66.56,98.54 ; J24.15 68.31,98.54 ; J25.13 51.36,76.44 ; J25.13 51.36,74.69 ; J25.13 49.61,76.44 ; J25.13 49.61,74.69 ; J24.19 68.31,103.62 ; J24.19 66.56,101.87 ; J24.19 66.56,103.62 ; J24.19 68.31,101.87 ; 57.29,112 J15.2 59.04,112 ; v2(110.02,92.63) 109.95,92.63 C7.2 ; 36.91,74.69 J25.3 ; J25.3 38.66,74.69 ; J25.3 36.91,76.44 ; J25.3 38.66,76.44 ; TP7.1 73.39,75.55 ; TP7.1 70.88,73.04 ; TP7.1 73.39,73.04 ; TP7.1 70.88,75.55 ; 39.45,76.44 J25.5 ; J25.5 41.2,74.69 ; J25.5 39.45,74.69 ; J25.5 41.2,76.44 ; J16.C33 v1(130.3,11.81) ; 44.53,74.69 J25.9 ; J25.9 44.53,76.44 ; J25.9 46.28,74.69 ; J25.9 46.28,76.44 ; J17.3 81.11,35.22 ; J17.3 78.66,37.68 ; J17.3 81.11,37.68 ; J17.3 78.66,35.22 ; TP5.1 39.48,56.25 ; TP5.1 36.97,53.74 ; TP5.1 36.97,56.25 ; TP5.1 39.48,53.74 ; J24.11 68.31,93.46 ; J24.11 66.56,91.71 ; J24.11 68.31,91.71 ; J24.11 66.56,93.46 ; v2(113.22,95.03) v2(113.22,95.83) 113.04,96.01 112.61,96.01 v2(112.42,95.83) v2(112.42,95.03) ; J16.A20 147.32,8.51 v1(147.57,8.38) ; 145.17,78.96 J21.6 ; J21.6 146.93,78.96 ; J21.6 146.93,77.2 ; J21.6 145.17,77.2 ; J16.G38 v2(124.97,16.89) ; 66.56,101.08 J24.17 ; J24.17 66.56,99.33 ; J24.17 68.31,99.33 ; J24.17 68.31,101.08 ; J23.2 9.2,48.44 ; J23.2 9.2,45.03 ; J23.2 5.79,48.44 ; J23.2 5.79,45.03 ; v2(114.82,92.63) 114.82,92.77 C187.2 ; J25.11 48.82,74.69 ; J25.11 48.82,76.44 ; J25.11 47.07,76.44 ; J25.11 47.07,74.69 ; J24.7 68.31,88.38 ; J24.7 66.56,88.38 ; J24.7 66.56,86.63 ; J24.7 68.31,86.63 ; 52.15,74.69 J25.15 ; J25.15 52.15,76.44 ; J25.15 53.9,74.69 ; J25.15 53.9,76.44 ; 47.13,112 J15.10 47.13,110.25 ; J21.2 146.93,84.04 ; J21.2 145.17,82.28 ; J21.2 146.93,82.28 ; J21.2 145.17,84.04 ; v1(123.57,14.99) 123.44,15.11 J16.F39 ; C178.2 113.16,90.23 v2(113.22,90.23) ; C88.2 83.69,63.25 84.07,62.87 v1(84.07,62.1) ; 66.27,81.05 J24.1 ; J24.1 66.27,78.71 ; J24.1 68.61,78.71 ; J24.1 68.61,81.05 ; 41.99,76.44 J25.7 ; J25.7 43.74,76.44 ; J25.7 41.99,74.69 ; J25.7 43.74,74.69 ; 153.77,103.66 JP1.3 ; JP1.3 153.77,101.83 ; JP1.3 155.6,101.83 ; JP1.3 155.6,103.66 ; 34.07,74.4 J25.1 ; J25.1 34.07,76.73 ; J25.1 36.41,76.73 ; J25.1 36.41,74.4 ; J16.C28 v1(137.67,11.81) ; C13.2 116.79,87.46 v2(116.42,87.83) ; C186.2 114.02,92.76 v2(114.02,92.63) ; J24.13 68.31,94.25 ; J24.13 66.56,96 ; J24.13 66.56,94.25 ; J24.13 68.31,96 ; SW2.1 18.1,76.09 ; SW2.1 15.76,76.09 ; SW2.1 18.1,73.75 ; SW2.1 15.76,73.75 ; C184.2 112.42,92.76 v2(112.42,92.63) ; 57.23,74.69 J25.19 ; J25.19 58.98,74.69 ; J25.19 57.23,76.44 ; J25.19 58.98,76.44 ; v1(137.92,9.65) 138.3,10.03 J16.B27 ; v2(109.22,95.03) 109.11,94.92 C26.2 ; C69.2 87.76,66.93 v1(87.5,67.18) ; TP6.1 35.93,106.31 ; TP6.1 33.42,106.31 ; TP6.1 33.42,108.82 ; TP6.1 35.93,108.82 ; J17.5 86.19,42.76 ; J17.5 83.74,40.3 ; J17.5 86.19,40.3 ; J17.5 83.74,42.76 ; v2(114.02,91.83) 114.12,91.83 C174.2 ; C57.2 v1(84.58,52.83) ; C33.2 113.41,85.6 v1(112.9,85.09) 113.28,84.71 C34.2 ; v2(111.62,92.63) 111.62,92.77 C183.2 ; J21.8 146.93,74.66 ; J21.8 145.17,74.66 ; J21.8 145.17,76.42 ; J21.8 146.93,76.42 ; C87.2 85.34,62.36 v1(85.09,62.1) ; C171.2 114.09,91.03 v2(114.02,91.03) ; 177.78,70.47 TP9.1 177.78,67.96 ; C182.2 110.87,92.68 v2(110.82,92.63) ; JP3.3 40.03,111.48 ; JP3.3 38.2,111.48 ; JP3.3 38.2,113.31 ; JP3.3 40.03,113.31 ; 77.1,97.17 TP3.1 ; TP3.1 77.1,99.68 ; TP3.1 79.61,99.68 ; TP3.1 79.61,97.17 ; J16.A33 v1(131.32,8.76) ; J16.C21 v2(146.69,11.3) J16.C20 ; C185.2 113.22,92.72 v2(113.22,92.63) ; C4.2 112.52,86.11 v1(112.78,85.85) 113.28,86.36 C5.2 ; J16.B34 v1(129.03,10.03) ; 66.56,85.84 J24.5 ; J24.5 68.31,85.84 ; J24.5 68.31,84.09 ; J24.5 66.56,84.09 ; J16.J38 v1(124.97,19.43) ; J16.G5 v2(166.37,16.76) ; J16.A28 v1(137.41,8.51) ; U7.8 v1(168.4,62.46) ; J16.B19 v2(149.86,10.03)
  BOTTOM w0.381: v4(174.69,96.01) v4(173.99,96.01) U11.3 v1(172.08,96.01) ; v1(176.16,77.87) U9.17 176.16,79.96 v4(176.21,80.01) ; v1(172.21,81.41) U9.3 v4(174.11,81.41) v4(174.81,81.41) ; v4(174.69,95.31) 174.64,95.36 U11.2 v1(172.1,95.36) ; v4(174.69,96.71) 174.64,96.66 U11.4 v1(172.1,96.66) ; v2(167.64,16.38) 167.64,16.26 167.13,15.75 ; J16.G11 v2(159.26,17.02) ; v1(160.13,78.37) U8.7 157.24,78.37 v4(156.59,77.72) ; C170.2 114.82,94.81 v2(114.82,95.03) ; v4(176.91,81.41) U9.13 v1(178.94,81.41) ; v1(178.93,80.76) U9.14 176.26,80.76 v4(176.21,80.71) ; v1(179.45,96.01) U11.13 v4(176.79,96.01) v4(176.09,96.01) ; v2(111.62,95.03) 111.45,95.03 ; v1(172.23,80.76) U9.2 174.86,80.76 v4(175.51,81.41) v4(176.21,81.41) ; v4(176.09,94.61) 176.04,94.56 U11.17 v1(176.04,92.47) ; J16.D3 v2(168.28,13.21) ; J16.J5 v2(166.37,19.3) ; v1(172.23,82.06) U9.4 174.76,82.06 v4(174.81,82.11) ; v4(176.09,95.31) 176.14,95.36 U11.14 v1(178.8,95.36) ; C32.2 115.62,94.84 v2(115.62,95.03) ; v1(178.93,96.66) U11.12 176.14,96.66 v4(176.09,96.71) ; J16.J11 v2(159.38,19.43) ; U10.2 v1(19.44,53.2) ; v2(114.02,95.03) 114.02,94.82 C173.2 ; U6.7 18.68,60.69 v1(18.92,60.45) ; v4(176.21,82.11) 176.26,82.06 U9.12 v1(178.93,82.06) ; v2(168.91,15.11) v2(167.64,13.84) ; v2(166.37,13.84) 167,13.84
  BOTTOM w0.508: C65.2 88.26,55.88 v1(88.14,56.01) ; v4(125.35,100.58) C344.2 ; C66.2 89.28,55.88 v1(89.15,56.01) ; v1(153.03,84.46) 153.42,84.07 C109.2 ; v1(131.44,100.58) C345.2 ; C10.2 128.14,103.12 v4(128.52,103.51) ; 130.3,100.56 C346.2 130.28,100.36 v4(130.28,100.58) ; v4(126.49,100.58) C343.2 ; C72.2 v1(75.95,56.01)
  vias: v1(1.52,99.69) v1(1.52,98.43) v1(1.52,90.81) v1(1.52,89.41) v1(2.41,99.19) v1(2.41,90.17) v1(3.3,99.69) v1(3.3,98.43) v1(3.3,90.81) v1(3.3,89.41) v1(6.98,99.69) v1(6.98,98.43) v1(6.98,90.81) v1(7.11,89.53) v1(7.24,103.63) v1(7.49,92.96) v1(7.87,99.06) v1(7.87,90.17) v1(7.87,77.22) v1(8.51,92.96) v1(8.76,99.69) v1(8.76,98.43) v1(8.76,90.81) v1(8.76,89.53) v1(10.79,67.31) v1(10.79,66.29) v1(10.94,101.58) v1(11.18,66.8) v1(11.66,64.96) v1(11.81,113.28) v1(12.45,63.61) v1(12.45,62.47) v1(13.21,91.31) v1(13.46,113.28) v1(13.59,95.89) v1(13.59,93.73) v1(13.84,103.12) v1(14.25,100.38) v1(14.61,90.78) v1(14.99,115.06) v1(15.11,96.29) v1(15.64,103.36) v1(15.75,115.57) v1(16.13,109.86) v1(16.51,95.73) v1(16.73,58.8) v1(18.03,58.8) v1(18.16,96.52) v1(18.8,93.34) v1(19.05,90.3) v1(19.3,50.29) v1(19.59,110.74) v1(21.84,53.34) v1(22.61,52.96) v1(24,78.08) v1(24.38,98.3) v1(24.51,92.58) v1(24.51,64.64) v1(24.66,66.04) v1(24.89,94.49) v1(24.89,45.47) v1(24.89,44.83) v1(24.89,44.07) v1(25.78,69.34) v1(25.78,67.82) v1(25.78,63.5) v1(25.78,45.47) v1(25.78,44.7) v1(25.78,44.07) v1(25.91,90.55) v1(26.16,62.87) v1(26.54,68.58) v1(26.54,63.37) v1(26.67,45.59) v1(26.67,44.83) v1(26.67,44.07) v1(26.7,109.79) v1(27.05,92.58) v1(27.18,69.34) v1(27.18,67.95) v1(28.21,46.1) v1(28.45,98.17) v1(28.45,64.39) v1(28.45,63.12) v1(29.21,94.36) v1(29.21,63.75) v1(29.34,90.55) v1(29.84,63.12) v1(29.97,105.28) v1(29.97,95.12) v1(29.97,92.58) v1(29.97,64.39) v1(30.1,80.28) v1(30.73,104.65) v1(30.86,115.7) v1(30.86,114.17) v1(31.37,63.63) v1(31.5,114.94) v1(31.75,46.1) v1(31.88,63.25) v1(32,115.7) v1(32,114.17) v1(32,89.53) v1(32,87.76) v1(32.38,63.63) v1(32.51,103.25) v1(32.89,46.86) v1(33.4,102.74) v1(33.4,46.48) v1(33.53,62.89) v1(34.67,90.68) v1(34.92,103.25) v1(35.05,62.89) v1(35.94,102.62) v1(36.45,62.48) v1(37.47,50.17) v1(38.1,89.53) v1(43.69,94.23) v1(43.69,92.33) v1(43.81,90.3) v1(44.07,87.38) v1(45.97,84.58) v1(46.48,96.39) v1(46.61,90.42) v1(46.74,93.34) v1(47.88,87.38) v1(48.39,84.71) v1(49.53,50.17) v1(49.53,45.72) v1(49.53,41.28) v1(49.53,36.83) v1(50.55,93.09) v1(50.93,90.68) v1(51.56,87.25) v1(52.96,84.58) v1(53.47,96.39) v1(53.47,90.35) v1(53.47,88.35) v1(53.98,93.85) v1(58.17,115.95) v1(60.94,125.94) v1(64.77,59.97) v1(64.77,55.14) v1(65.66,51.23) v1(67.77,132.77) v1(70.69,122.9) v1(70.94,51.23) v1(77.19,116.35) v1(77.72,51.18) v1(78.36,65.66) v1(78.99,70.76) v1(78.99,67.56) v1(80.01,50.17) v1(80.52,107.33) v1(81.15,54.48) v1(81.15,53.34) v1(81.91,70.76) v1(81.91,67.56) v1(83.06,62.1) v1(83.06,61.09) v1(83.06,60.07) v1(83.06,59.06) v1(83.06,58.04) v1(83.06,57.02) v1(83.06,56.01) v1(83.18,70.82) v1(83.18,67.56) v1(83.44,49.78) v1(83.69,50.93) v1(83.9,45.64) v1(84.07,61.09) v1(84.07,60.07) v1(84.07,59.06) v1(84.07,58.04) v1(84.07,57.02) v1(84.07,56.01) v1(84.33,47.75) v1(84.45,49.78) v1(85.09,61.09) v1(85.09,60.07) v1(85.09,59.06) v1(85.09,58.04) v1(85.09,57.02) v1(85.09,56.01) v1(85.22,46.36) v1(85.85,52.96) v1(86.11,62.1) v1(86.11,61.09) v1(86.11,60.07) v1(86.11,59.06) v1(86.11,58.04) v1(86.11,57.02) v1(86.11,56.01) v1(86.27,113.08) v1(86.23,70.82) v1(86.23,67.56) v1(87.12,62.1) v1(87.12,61.09) v1(87.12,60.07) v1(87.12,59.06) v1(87.12,58.04) v1(87.12,57.02) v1(87.12,56.01) v1(88.14,62.1) v1(88.14,61.09) v1(88.14,60.07) v1(88.14,59.06) v1(88.14,58.04) v1(88.14,57.02) v1(89.03,50.93) v1(89.15,62.1) v1(89.15,61.09) v1(89.15,60.07) v1(89.15,59.06) v1(89.15,58.04) v1(89.15,57.02) v1(89.25,44.03) v1(89.71,41.33) v1(90.9,42.38) v1(91.31,51.94) v1(91.67,41.2) v1(91.69,37.85) v1(93.6,68.71) v1(93.6,65.41) v1(93.73,35.69) v1(93.98,142.78) v1(94.11,46.86) v1(94.66,115.77) v1(94.87,35.69) v1(95.25,61.21) v1(95.25,55.75) v1(95.25,45.59) v1(95.38,39.75) v1(95.5,44.07) v1(96.01,35.69) v1(96.65,50.29) v1(96.65,44.83) v1(96.77,65.66) v1(96.77,60.45) v1(97.03,59.31) v1(97.03,57.66) v1(97.03,39.75) v1(97.41,35.15) v1(98.04,55.63) v1(98.04,50.17) v1(98.58,133.73) v1(98.68,124.46) v1(98.68,45.59) v1(99.31,54.61) v1(99.82,44.32) v1(99.82,39.64) v1(100.71,95.89) v1(101.12,95.15) v1(101.12,90.07) v1(102.23,95.17) v1(102.63,100.42) v1(102.78,115.77) v1(103.28,95.15) v1(103.63,142.78) v1(103.76,97.03) v1(104.52,92.96) v1(104.52,91.82) v1(104.78,102.57) v1(108.46,104.39) v1(109.6,43.31) v1(110.49,43.31) v1(111.38,43.25) v1(111.51,104.39) v1(112.39,43.31) v1(113.31,111.94) v1(113.41,43.31) v1(114.68,54.74) v1(114.93,104.39) v1(116.08,38.91) v1(116.2,52.96) v1(116.33,36.04) v1(117.47,101.24) v1(117.47,99.44) v1(117.98,104.39) v1(118.11,100.2) v1(119.13,78.21) v1(119.38,1.27) v1(119.53,87.22) v1(120.07,86.66) v1(120.52,87.25) v1(121.54,80.9) v1(121.63,102.55) v1(121.92,90.42) v1(121.92,18.92) v1(121.92,16.38) v1(121.92,13.84) v1(121.92,11.3) v1(121.92,8.76) v1(122.3,142.78) v1(122.81,80.26) v1(122.98,115.77) v1(123.19,20.19) v1(123.19,17.65) v1(123.19,12.57) v1(123.19,10.03) v1(123.32,91.95) v1(123.78,100.39) v1(124.08,80.9) v1(124.46,13.84) v1(124.46,11.3) v1(124.46,10.03) v1(125.37,94.36) v1(125.73,12.57) v1(125.73,8.76) v1(126.11,90.42) v1(127.04,133.73) v1(127,124.46) v1(127,20.19) v1(127,17.65) v1(127,15.11) v1(127,11.3) v1(127,8.76) v1(128.27,18.92) v1(128.27,16.38) v1(128.27,13.84) v1(128.27,10.03) v1(130.81,20.19) v1(130.81,17.65) v1(130.81,15.11) v1(131.11,115.77) v1(131.95,142.78) v1(132.08,18.92) v1(132.08,16.38) v1(132.08,13.84) v1(132.08,11.3) v1(132.08,8.76) v1(133.35,10.03) v1(134.62,20.19) v1(134.62,17.65) v1(134.62,15.11) v1(134.62,10.03) v1(135.89,18.92) v1(135.89,16.38) v1(135.89,13.84) v1(135.89,11.3) v1(135.89,8.76) v1(137.16,12.57) v1(138.43,20.19) v1(138.43,17.65) v1(138.43,15.11) v1(139.47,113.06) v1(139.7,18.92) v1(139.7,16.38) v1(139.7,13.84) v1(139.7,10.03) v1(140.97,94.49) v1(140.97,12.57) v1(140.97,11.3) v1(140.97,8.76) v1(141.17,87.76) v1(142.19,94.04) v1(142.24,20.19) v1(142.24,17.65) v1(142.24,15.11) v1(142.24,11.3) v1(142.24,8.76) v1(143.38,93.6) v1(143.51,18.92) v1(143.51,16.38) v1(143.51,13.84) v1(143.51,10.03) v1(144.78,12.57) v1(144.78,10.03) v1(145.22,107.32) v1(146.05,20.19) v1(146.05,17.65) v1(146.05,15.11) v1(146.05,8.76) v1(146.18,93.6) v1(147.37,94.04) v1(147.32,18.92) v1(147.32,16.38) v1(147.32,13.84) v1(148.48,116.35) v1(148.59,94.49) v1(148.59,12.57) v1(149.22,67.44) v1(149.86,20.19) v1(149.86,17.65) v1(149.86,15.11) v1(150.11,80.77) v1(150.11,79.5) v1(150.88,80.14) v1(151.13,18.92) v1(151.13,16.38) v1(151.13,13.84) v1(151.13,11.3) v1(151.13,8.76) v1(151.51,79.38) v1(151.76,80.9) v1(152.4,12.57) v1(152.4,11.3) v1(152.4,8.76) v1(152.78,71.37) v1(153.67,20.19) v1(153.67,17.65) v1(153.67,15.11) v1(154.18,86.49) v1(154.94,83.69) v1(154.94,71.5) v1(154.94,70.61) v1(154.94,18.92) v1(154.94,16.38) v1(154.94,13.84) v1(155.04,122.9) v1(155.32,86.74) v1(155.57,84.71) v1(155.7,85.85) v1(155.89,71.35) v1(156.34,88.14) v1(156.46,89.66) v1(156.84,57.79) v1(156.97,56.64) v1(157.1,88.9) v1(157.24,72.14) v1(157.35,86.11) v1(157.61,91.57) v1(157.73,89.66) v1(157.73,88.14) v1(157.96,93.22) v1(157.99,85.85) v1(158.09,132.64) v1(158.37,94.62) v1(158.38,72.14) v1(158.5,85.47) v1(159.26,57.79) v1(159.38,56.52) v1(159.77,63.25) v1(160.15,68.71) v1(160.78,68.33) v1(161.04,63.25) v1(162.05,77.72) v1(162.05,76.42) v1(162.18,68.1) v1(163.32,64.52) v1(163.83,10.03) v1(164.59,64.52) v1(164.91,125.82) v1(165.61,64.52) v1(165.99,66.55) v1(166.37,65.91) v1(166.37,8.76) v1(166.65,92.46) v1(166.65,90.93) v1(166.6,69.6) v1(166.6,68.07) v1(166.75,77.85) v1(166.75,76.33) v1(167,80.01) v1(167.11,94.23) v1(167.13,70.99) v1(167.49,79.25) v1(167.6,63.27) v1(167.6,62.46) v1(167.64,8.76) v1(168.4,63.27) v1(168.76,94.36) v1(168.76,92.84) v1(168.91,79.76) v1(168.91,78.23) v1(169.2,63.27) v1(169.2,62.46) v1(169.54,67.56) v1(171.2,64.52) v1(171.96,74.8) v1(172.21,89.28) v1(172.21,64.52) v1(172.59,74.42) v1(174.24,60.96) v1(174.75,102.01) v1(174.75,60.2) v1(174.88,87.4) v1(174.88,58.93) v1(174.88,57.79) v1(174.98,62.48) v1(176.66,102.01) v1(176.69,89.64) v1(176.78,87.4) v1(176.78,75.06) v1(178.31,90.68) v1(178.44,75.95) v1(179.7,5.72) v1(179.7,1.91) v2(103.12,78.36) v2(104.65,85.85) v2(104.65,85.09) v2(104.65,84.07) v2(105.49,84.2) v2(106.04,79.76) v2(106.81,95.12) v2(107.62,84.2) v2(107.77,92.58) v2(107.7,83.31) v2(111.25,85.09) v2(111.62,91.83) v2(111.62,91.03) v2(111.62,90.23) v2(111.62,87.83) v2(112.42,91.83) v2(112.42,91.03) v2(112.42,90.23) v2(113.22,91.83) v2(113.22,91.03) v2(114.02,90.23) v2(115.62,87.83) v2(116.08,85.55) v2(116.42,88.63) v2(117.22,89.43) v2(118.52,89.31) v2(118.92,90.81) v2(119.76,85.72) v2(120.19,90.73) v2(120.4,85.72) v2(153.67,10.03) v2(154.94,10.03) v2(156.21,12.57) v2(156.21,11.3) v2(156.21,8.76) v2(157.48,20.19) v2(157.48,17.65) v2(157.48,15.11) v2(157.48,11.3) v2(157.48,8.76) v2(158.75,13.84) v2(158.75,10.03) v2(160.02,12.57) v2(160.02,10.03) v2(161.29,20.19) v2(161.29,17.65) v2(161.29,15.11) v2(161.29,11.3) v2(161.29,8.76) v2(162.56,18.92) v2(162.56,16.38) v2(162.56,13.84) v2(162.56,11.3) v2(162.56,8.76) v2(163.83,12.57) v2(165.1,20.19) v2(165.1,17.65) v2(165.1,12.57) v2(165.1,10.03) v2(166.37,11.3) v2(167.64,18.92) v2(167.64,11.3) v2(168.91,20.19) v2(168.91,17.65) v2(168.91,10.03) v2(170.18,20.19) v2(170.18,15.11) v2(170.18,12.57) v2(170.18,10.03) v2(171.45,18.92) v2(171.45,16.38) v2(171.45,13.84) v2(171.45,11.3) v2(171.45,8.76) v4(2.29,72.9) v4(2.29,71.12) v4(2.41,86.87) v4(2.41,85.09) v4(2.41,79.76) v4(2.41,77.98) v4(3.17,72.01) v4(3.3,85.98) v4(3.3,78.87) v4(3.68,55.88) v4(3.68,54.1) v4(4.19,72.9) v4(4.19,71.12) v4(4.32,86.87) v4(4.32,85.09) v4(4.32,79.76) v4(4.32,77.98) v4(4.32,66.17) v4(4.32,64.39) v4(4.57,54.99) v4(5.21,65.28) v4(5.33,118.75) v4(5.33,116.97) v4(5.59,55.88) v4(5.59,54.1) v4(6.22,117.86) v4(6.22,66.17) v4(6.22,64.39) v4(7.24,118.75) v4(7.24,116.97) v4(8.13,74.55) v4(8.13,72.77) v4(8.51,59.69) v4(8.51,57.91) v4(9.02,73.66) v4(9.4,58.8) v4(10.03,74.55) v4(10.03,72.77) v4(10.41,59.69) v4(10.41,57.91) v4(11.68,41.15) v4(11.68,39.37) v4(11.94,118.75) v4(11.94,116.97) v4(12.57,40.26) v4(12.83,117.86) v4(13.59,56.52) v4(13.59,54.74) v4(13.59,41.15) v4(13.59,39.37) v4(13.84,118.75) v4(13.84,116.97) v4(14.48,89.15) v4(14.48,87.38) v4(14.48,55.63) v4(15.37,88.27) v4(15.49,56.52) v4(15.49,54.74) v4(16.38,89.15) v4(16.38,87.38) v4(16.63,65.66) v4(16.63,64.96) v4(16.63,64.26) v4(16.63,63.56) v4(16.63,62.86) v4(17.14,108.08) v4(17.33,65.66) v4(17.33,64.96) v4(17.33,64.26) v4(17.33,63.56) v4(17.33,62.86) v4(18.03,107.19) v4(18.03,70.36) v4(18.03,65.66) v4(18.03,64.96) v4(18.03,64.26) v4(18.03,63.56) v4(18.03,62.86) v4(18.73,65.66) v4(18.73,64.96) v4(18.73,64.26) v4(18.73,63.56) v4(18.73,62.86) v4(18.92,71.25) v4(19.05,108.08) v4(19.43,65.66) v4(19.43,64.96) v4(19.43,64.26) v4(19.43,63.56) v4(19.43,62.86) v4(19.68,102.87) v4(19.94,70.36) v4(20.32,118.75) v4(20.32,116.97) v4(20.57,103.76) v4(20.7,57.79) v4(20.7,56.01) v4(21.21,117.86) v4(21.59,102.87) v4(21.59,56.9) v4(22.23,118.75) v4(22.23,116.97) v4(22.61,57.79) v4(22.61,56.01) v4(24,75.44) v4(24,73.66) v4(24.89,74.55) v4(25.4,53.34) v4(25.4,51.56) v4(25.91,75.44) v4(25.91,73.66) v4(26.29,52.45) v4(27.3,53.34) v4(27.3,51.56) v4(27.56,39.62) v4(27.56,37.85) v4(28.45,38.74) v4(29.46,39.62) v4(29.46,37.85) v4(29.72,57.66) v4(29.72,55.88) v4(30.35,68.2) v4(30.35,66.42) v4(30.61,56.77) v4(31.24,67.31) v4(31.62,57.66) v4(31.62,55.88) v4(32.26,68.2) v4(32.26,66.42) v4(33.53,54.1) v4(33.53,52.32) v4(33.91,113.03) v4(33.91,111.25) v4(34.29,118.11) v4(34.29,116.33) v4(34.42,53.21) v4(34.8,112.14) v4(34.8,36.45) v4(34.8,34.67) v4(35.05,41.53) v4(35.05,39.75) v4(35.18,117.22) v4(35.43,54.1) v4(35.43,52.32) v4(35.69,35.56) v4(35.81,113.03) v4(35.81,111.25) v4(35.94,40.64) v4(36.2,118.11) v4(36.2,116.33) v4(36.7,36.45) v4(36.7,34.67) v4(36.96,41.53) v4(36.96,39.75) v4(37.97,73.28) v4(37.97,71.5) v4(38.86,72.39) v4(39.88,73.28) v4(39.88,71.5) v4(40.51,117.86) v4(40.51,116.08) v4(41.4,116.97) v4(42.42,117.86) v4(42.42,116.08) v4(42.55,47.62) v4(42.67,48.77) v4(42.8,101.22) v4(43.18,68.2) v4(43.18,66.42) v4(43.31,73.41) v4(43.31,71.63) v4(43.69,102.11) v4(44.07,67.31) v4(44.07,55.5) v4(44.07,53.72) v4(44.2,72.52) v4(44.7,103) v4(44.7,101.22) v4(44.83,44.45) v4(44.96,54.61) v4(44.96,42.67) v4(45.09,68.2) v4(45.09,66.42) v4(45.21,73.41) v4(45.21,71.63) v4(45.34,120.14) v4(45.34,118.36) v4(45.97,55.5) v4(45.97,53.72) v4(46.23,119.25) v4(47.24,120.14) v4(47.24,118.36) v4(47.75,73.15) v4(47.75,71.37) v4(48.64,72.26) v4(48.9,124.46) v4(48.9,122.68) v4(49.66,73.15) v4(49.66,71.37) v4(49.78,123.57) v4(50.46,127.45) v4(50.42,64.52) v4(50.42,62.74) v4(50.55,55.5) v4(50.55,53.72) v4(50.8,124.46) v4(50.8,122.68) v4(51,126.91) v4(51.09,128.08) v4(51.31,63.63) v4(51.44,54.61) v4(51.54,126.37) v4(51.63,127.54) v4(51.72,128.71) v4(51.82,45.21) v4(51.82,43.43) v4(52.08,125.83) v4(52.16,127) v4(52.25,128.17) v4(52.32,64.52) v4(52.32,62.74) v4(52.45,55.5) v4(52.45,53.72) v4(52.61,125.29) v4(52.7,126.46) v4(52.7,44.32) v4(52.83,129.41) v4(52.79,127.63) v4(53.24,125.92) v4(53.33,127.09) v4(53.47,39.12) v4(53.47,37.34) v4(53.72,45.21) v4(53.72,43.43) v4(53.87,126.55) v4(53.85,73.15) v4(53.85,71.37) v4(54.23,128.02) v4(54.23,122.56) v4(54.23,120.78) v4(54.36,38.23) v4(54.74,72.26) v4(54.86,131.32) v4(55.12,121.67) v4(55.37,39.12) v4(55.37,37.34) v4(55.49,132.48) v4(55.5,126.75) v4(55.75,73.15) v4(55.75,71.37) v4(56.03,131.94) v4(56.12,133.11) v4(56.13,122.56) v4(56.13,120.78) v4(56.26,129.92) v4(56.57,131.4) v4(56.65,132.57) v4(56.74,133.74) v4(56.77,125.48) v4(56.9,45.97) v4(56.9,44.2) v4(57.1,130.86) v4(57.19,132.03) v4(57.28,133.2) v4(57.53,128.65) v4(57.64,130.32) v4(57.66,81.15) v4(57.73,131.49) v4(57.82,132.66) v4(57.79,45.09) v4(58.04,124.21) v4(58.27,130.95) v4(58.36,132.12) v4(58.49,133.84) v4(58.8,127.38) v4(58.8,45.97) v4(58.8,44.2) v4(58.9,131.58) v4(59.03,129.17) v4(59.44,49.66) v4(59.44,47.88) v4(59.75,133.84) v4(59.75,132.59) v4(59.8,136.79) v4(59.84,135.19) v4(59.82,38.99) v4(59.82,37.21) v4(60.07,126.11) v4(60.07,122.68) v4(60.34,136.25) v4(60.38,130.52) v4(60.29,129.17) v4(60.29,127.92) v4(60.33,48.77) v4(60.43,137.42) v4(60.71,38.1) v4(60.88,135.71) v4(60.97,136.88) v4(61.06,138.05) v4(61.09,133.93) v4(61.34,49.66) v4(61.34,47.88) v4(61.41,135.17) v4(61.5,136.34) v4(61.59,137.51) v4(61.63,129.26) v4(61.72,123.32) v4(61.72,38.99) v4(61.72,37.21) v4(61.95,134.63) v4(61.98,128.14) v4(62.04,135.8) v4(62.13,136.97) v4(62.23,138.68) v4(62.67,136.43) v4(62.58,135.26) v4(62.87,124.46) v4(62.99,111) v4(62.99,109.22) v4(63.21,135.89) v4(63.25,133.4) v4(63.25,77.09) v4(63.25,75.31) v4(63.5,117.73) v4(63.5,115.95) v4(63.63,137.29) v4(63.75,129.79) v4(63.88,110.11) v4(64.13,76.2) v4(64.26,140.59) v4(64.39,124.71) v4(64.39,116.84) v4(64.51,133.4) v4(64.51,132.14) v4(64.6,134.74) v4(64.83,141.82) v4(64.87,122.62) v4(64.9,136.02) v4(64.9,111) v4(64.9,109.22) v4(65.15,123.95) v4(65.15,77.09) v4(65.15,75.31) v4(65.37,141.28) v4(65.46,142.45) v4(65.41,117.73) v4(65.41,115.95) v4(65.53,131.7) v4(65.53,56.01) v4(65.53,54.23) v4(65.66,139.19) v4(65.85,133.49) v4(65.9,140.74) v4(65.99,141.91) v4(66.04,38.86) v4(66.04,37.08) v4(66.08,143.07) v4(66.17,134.75) v4(66.3,121.18) v4(66.44,140.2) v4(66.42,55.12) v4(66.53,141.37) v4(66.62,142.54) v4(66.93,137.92) v4(66.93,37.97) v4(67.07,140.83) v4(66.98,139.66) v4(67.16,142) v4(67.31,48.51) v4(67.31,46.74) v4(67.44,133.48) v4(67.47,120.55) v4(67.44,56.01) v4(67.44,54.23) v4(67.61,140.29) v4(67.7,141.46) v4(67.94,38.86) v4(67.94,37.08) v4(68.24,140.92) v4(68.2,136.65) v4(68.19,119.84) v4(68.2,47.62) v4(68.83,129.03) v4(68.91,118.58) v4(69.21,130.81) v4(69.21,48.51) v4(69.21,46.74) v4(69.47,135.38) v4(69.47,128.4) v4(70.1,103) v4(70.1,101.22) v4(70.23,91.69) v4(70.23,89.92) v4(70.34,117.14) v4(70.36,86.74) v4(70.36,84.96) v4(70.36,79.12) v4(70.36,77.34) v4(70.48,131.95) v4(70.87,133.48) v4(70.87,111.38) v4(70.87,109.6) v4(70.97,128.73) v4(70.99,102.11) v4(71.12,90.81) v4(71.25,85.85) v4(71.25,78.23) v4(71.75,110.49) v4(71.96,117.68) v4(72.01,103) v4(72.01,101.22) v4(72.14,115.35) v4(72.14,91.69) v4(72.14,89.92) v4(72.26,86.74) v4(72.26,84.96) v4(72.26,79.12) v4(72.26,77.34) v4(72.41,127.29) v4(72.68,116.96) v4(72.77,111.38) v4(72.77,109.6) v4(72.9,39.5) v4(72.9,37.72) v4(73.04,126.12) v4(73.53,99.57) v4(73.53,97.79) v4(73.58,113.91) v4(73.76,125.4) v4(73.79,38.61) v4(74.42,98.68) v4(74.8,39.5) v4(74.8,37.72) v4(75.01,124.68) v4(75.28,112.74) v4(75.44,99.57) v4(75.44,97.79) v4(75.91,121.63) v4(76.33,93.09) v4(76.33,91.31) v4(76.45,123.25) v4(76.58,138.3) v4(76.58,136.53) v4(76.63,120.91) v4(76.58,85.85) v4(76.72,111.3) v4(76.83,130.56) v4(76.83,128.78) v4(77.22,92.2) v4(77.22,87.88) v4(77.22,74.93) v4(77.34,48.01) v4(77.34,46.23) v4(77.47,137.41) v4(77.72,129.67) v4(78.1,72.52) v4(78.25,121.45) v4(78.23,93.09) v4(78.23,91.31) v4(78.23,47.12) v4(78.49,138.3) v4(78.49,136.53) v4(78.49,77.72) v4(78.74,130.56) v4(78.74,128.78) v4(78.87,88.65) v4(79.05,110.41) v4(79.25,48.01) v4(79.25,46.23) v4(79.38,85.85) v4(79.5,141.99) v4(79.5,140.21) v4(79.63,65.41) v4(79.76,134.24) v4(79.76,132.46) v4(79.68,120.02) v4(80.01,75.06) v4(80.14,146.69) v4(80.14,144.91) v4(80.31,109.33) v4(80.39,141.1) v4(80.52,94.87) v4(80.52,93.09) v4(80.64,133.35) v4(80.64,102.74) v4(80.64,100.97) v4(80.64,79.25) v4(80.85,118.31) v4(81.03,145.8) v4(81.28,75.82) v4(81.28,74.04) v4(81.41,141.99) v4(81.41,140.21) v4(81.41,93.98) v4(81.38,88.65) v4(81.53,101.85) v4(81.56,86.06) v4(81.53,81.03) v4(81.66,134.24) v4(81.66,132.46) v4(81.66,83.69) v4(81.93,107.89) v4(82.04,146.69) v4(82.04,144.91) v4(82.04,90.17) v4(82.04,72.52) v4(82.17,74.93) v4(82.29,116.87) v4(82.42,94.87) v4(82.42,93.09) v4(82.55,138.3) v4(82.55,136.53) v4(82.55,102.74) v4(82.55,100.97) v4(82.68,122.94) v4(82.68,121.16) v4(82.8,130.56) v4(82.8,128.78) v4(82.8,77.09) v4(83.06,150.37) v4(83.06,148.59) v4(83.19,114.54) v4(83.18,91.31) v4(83.18,75.82) v4(83.18,74.04) v4(83.18,72.64) v4(83.44,137.41) v4(83.57,122.05) v4(83.69,129.67) v4(83.95,149.48) v4(84.07,78.49) v4(84.17,107.44) v4(84.35,113.37) v4(84.33,92.46) v4(84.45,138.3) v4(84.45,136.53) v4(84.45,73.79) v4(84.58,122.94) v4(84.58,121.16) v4(84.66,88.67) v4(84.58,83.69) v4(84.58,81.03) v4(84.71,130.56) v4(84.71,128.78) v4(84.86,86.08) v4(84.96,150.37) v4(84.96,148.59) v4(85.22,93.34) v4(85.47,89.41) v4(85.6,126.62) v4(85.6,124.84) v4(85.7,111.66) v4(86.11,146.69) v4(86.11,144.91) v4(86.15,109.42) v4(86.23,94.36) v4(86.46,90.4) v4(86.49,125.73) v4(86.49,101.98) v4(86.49,100.2) v4(86.74,85.85) v4(86.74,73.91) v4(86.99,145.8) v4(87.25,108.2) v4(87.25,104.27) v4(87.38,101.09) v4(87.38,88.65) v4(87.45,91.38) v4(87.5,126.62) v4(87.5,124.84) v4(87.63,151.26) v4(87.63,150.5) v4(87.63,149.73) v4(87.63,148.97) v4(87.63,148.21) v4(87.76,95.25) v4(87.88,112.52) v4(87.88,110.74) v4(88.01,146.69) v4(88.01,144.91) v4(88.14,103.25) v4(88.26,92.33) v4(88.39,101.98) v4(88.39,100.2) v4(88.51,151.26) v4(88.51,150.5) v4(88.51,149.73) v4(88.51,148.97) v4(88.51,148.21) v4(88.65,122.94) v4(88.65,121.16) v4(88.77,111.63) v4(88.9,88.01) v4(89.03,77.72) v4(89.15,95.25) v4(89.15,79.12) v4(89.28,92.46) v4(89.4,151.26) v4(89.4,150.5) v4(89.4,149.73) v4(89.4,148.97) v4(89.4,148.21) v4(89.53,122.05) v4(89.53,85.85) v4(89.79,112.52) v4(89.79,110.74) v4(90.17,101.09) v4(90.42,90.17) v4(90.42,88.39) v4(90.55,122.94) v4(90.55,121.16) v4(90.55,95.25) v4(90.73,150.78) v4(90.73,148.8) v4(90.73,147.01) v4(90.73,145.21) v4(90.73,143.41) v4(90.8,116.2) v4(90.8,114.43) v4(90.8,92.46) v4(91.09,141.08) v4(91.19,104.27) v4(91.31,98.3) v4(91.31,96.52) v4(91.31,89.28) v4(91.44,80.52) v4(91.69,115.32) v4(91.82,77.72) v4(92.07,95.25) v4(92.2,97.41) v4(92.2,92.46) v4(92.33,90.17) v4(92.33,88.39) v4(92.43,140.27) v4(92.71,116.2) v4(92.71,114.43) v4(93.22,98.3) v4(93.22,96.52) v4(93.22,84.58) v4(93.34,85.72) v4(93.34,83.31) v4(93.34,81.28) v4(93.47,95.25) v4(93.51,150.87) v4(93.51,148.89) v4(93.51,147.1) v4(93.51,145.3) v4(93.51,143.5) v4(93.6,92.46) v4(93.6,73.53) v4(93.73,103.89) v4(93.73,100.97) v4(93.85,112.52) v4(93.85,110.74) v4(93.85,77.72) v4(94.14,140.36) v4(94.11,90.68) v4(94.11,89.03) v4(94.11,75.31) v4(94.23,87) v4(94.36,137.67) v4(94.36,135.64) v4(94.36,131.95) v4(94.36,129.92) v4(94.36,127.38) v4(94.36,125.35) v4(94.74,151.26) v4(94.74,150.5) v4(94.74,149.73) v4(94.74,148.97) v4(94.74,148.21) v4(94.74,134.37) v4(94.74,133.35) v4(94.74,123.32) v4(94.74,121.28) v4(94.74,111.63) v4(94.87,146.43) v4(94.87,144.65) v4(94.87,95.25) v4(95.52,139.49) v4(95.52,138.41) v4(95.63,151.26) v4(95.63,150.5) v4(95.63,149.73) v4(95.63,148.97) v4(95.63,148.21) v4(95.76,145.54) v4(95.76,119) v4(95.76,112.52) v4(95.76,110.74) v4(95.88,129.16) v4(95.88,128.14) v4(95.88,117.35) v4(96.01,115.19) v4(96.39,81.15) v4(96.52,151.26) v4(96.52,150.5) v4(96.52,149.73) v4(96.52,148.97) v4(96.52,148.21) v4(96.52,95.25) v4(96.77,146.43) v4(96.77,144.65) v4(96.77,72.52) v4(96.9,100.97) v4(96.9,88.27) v4(97.03,90.04) v4(97.03,75.31) v4(97.23,99.01) v4(97.21,98.09) v4(97.28,113.28) v4(97.28,111.25) v4(97.28,109.09) v4(97.28,77.72) v4(97.41,85.22) v4(97.66,103.89) v4(97.79,150.11) v4(97.79,148.34) v4(97.79,83.44) v4(97.79,80.52) v4(97.92,95.25) v4(98.04,61.34) v4(98.37,98.93) v4(98.35,98.09) v4(98.53,89.15) v4(98.53,88.01) v4(98.53,84.76) v4(98.68,149.23) v4(99.19,77.72) v4(99.31,99.95) v4(99.29,96.01) v4(99.31,95.25) v4(99.69,150.11) v4(99.69,148.34) v4(99.95,61.72) v4(100.08,113.28) v4(100.08,111.38) v4(100.08,109.86) v4(100.33,100.97) v4(100.58,59.94) v4(100.83,151.26) v4(100.83,150.5) v4(100.83,149.73) v4(100.83,148.97) v4(100.83,148.21) v4(100.84,146.43) v4(100.84,144.65) v4(100.96,80.14) v4(101.35,115.19) v4(101.47,129.16) v4(101.47,128.14) v4(101.47,103.89) v4(101.6,119) v4(101.6,117.35) v4(101.72,151.26) v4(101.72,150.5) v4(101.72,149.73) v4(101.72,148.97) v4(101.72,148.21) v4(101.73,145.54) v4(101.73,139.45) v4(101.73,138.43) v4(101.85,105.16) v4(101.98,110.62) v4(102.01,98.96) v4(101.98,77.72) v4(101.98,67.56) v4(102.61,151.26) v4(102.61,150.5) v4(102.61,149.73) v4(102.61,148.97) v4(102.61,148.21) v4(102.62,134.37) v4(102.62,133.35) v4(102.62,123.32) v4(102.62,121.28) v4(102.74,146.43) v4(102.74,144.65) v4(103,137.67) v4(103,135.64) v4(103,131.95) v4(103,129.92) v4(103,127.38) v4(103,125.35) v4(103,113.67) v4(103,111.89) v4(103.22,140.36) v4(103.38,105.16) v4(103.5,60.83) v4(103.85,150.87) v4(103.85,148.89) v4(103.85,147.1) v4(103.85,145.3) v4(103.85,143.5) v4(103.84,98.17) v4(103.89,112.78) v4(104.27,103.89) v4(104.52,109.98) v4(104.52,59.94) v4(104.52,56.77) v4(104.65,99.44) v4(104.77,81.92) v4(104.92,140.27) v4(104.9,113.67) v4(104.9,111.89) v4(105.03,98.3) v4(105.41,126.87) v4(105.41,125.09) v4(105.79,97.03) v4(105.92,117.35) v4(105.92,115.57) v4(106.17,102.49) v4(106.27,141.08) v4(106.3,125.98) v4(106.63,150.78) v4(106.63,148.8) v4(106.63,147.01) v4(106.63,145.21) v4(106.63,143.41) v4(106.81,116.46) v4(106.81,110.36) v4(106.93,96.52) v4(107.31,126.87) v4(107.31,125.09) v4(107.31,81.92) v4(107.31,77.72) v4(107.31,72.77) v4(107.44,100.08) v4(107.44,61.59) v4(107.44,59.94) v4(107.44,57.02) v4(107.44,54.61) v4(107.82,117.35) v4(107.82,115.57) v4(107.95,151.26) v4(107.95,150.5) v4(107.95,149.73) v4(107.95,148.97) v4(107.95,148.21) v4(108.2,105.28) v4(108.51,102.69) v4(108.58,98.81) v4(108.71,144.4) v4(108.71,142.62) v4(108.69,111.91) v4(108.83,151.26) v4(108.83,150.5) v4(108.83,149.73) v4(108.83,148.97) v4(108.83,148.21) v4(108.84,134.24) v4(108.84,132.46) v4(108.84,122.68) v4(108.84,120.9) v4(108.97,113.67) v4(109.35,109.98) v4(109.6,143.51) v4(109.72,151.26) v4(109.72,150.5) v4(109.72,149.73) v4(109.72,148.97) v4(109.72,148.21) v4(109.73,133.35) v4(109.73,121.79) v4(109.73,98.81) v4(109.85,112.78) v4(109.83,111.94) v4(109.85,59.94) v4(109.85,56.77) v4(109.85,54.99) v4(109.98,35.94) v4(109.98,34.16) v4(110.49,63.12) v4(110.49,61.34) v4(110.62,144.4) v4(110.62,142.62) v4(110.74,134.24) v4(110.74,132.46) v4(110.74,122.68) v4(110.74,120.9) v4(110.74,55.88) v4(110.87,113.67) v4(110.87,111.89) v4(110.87,35.05) v4(111.38,103.25) v4(111.38,62.23) v4(111.63,148.08) v4(111.63,146.3) v4(111.76,137.92) v4(111.76,136.14) v4(111.76,126.37) v4(111.76,124.59) v4(111.76,105.28) v4(111.76,102.23) v4(111.76,56.77) v4(111.76,54.99) v4(111.89,35.94) v4(111.89,34.16) v4(112.39,63.12) v4(112.39,61.34) v4(112.39,59.94) v4(112.52,147.19) v4(112.65,137.03) v4(112.65,125.48) v4(112.65,98.68) v4(112.65,67.31) v4(112.78,100.97) v4(113.16,109.73) v4(113.28,105.03) v4(113.41,54.61) v4(113.54,148.08) v4(113.54,146.3) v4(113.66,137.92) v4(113.66,136.14) v4(113.66,126.37) v4(113.66,124.59) v4(113.66,102.11) v4(113.66,57.02) v4(114.3,32.51) v4(114.3,26.92) v4(114.3,21.34) v4(114.3,14.35) v4(114.3,10.16) v4(114.3,6.1) v4(114.3,1.78) v4(114.4,111.91) v4(114.68,144.4) v4(114.68,142.62) v4(114.68,105.16) v4(114.81,134.24) v4(114.81,132.46) v4(114.81,122.68) v4(114.81,120.9) v4(114.93,113.92) v4(114.93,103.25) v4(114.93,59.94) v4(115.57,143.51) v4(115.7,133.35) v4(115.7,121.79) v4(115.82,113.03) v4(115.82,100.08) v4(115.82,57.02) v4(115.95,151.26) v4(115.95,150.5) v4(115.95,149.73) v4(115.95,148.97) v4(115.95,148.21) v4(116.33,59.31) v4(116.33,35.69) v4(116.33,32.39) v4(116.33,27.18) v4(116.33,21.34) v4(116.33,14.99) v4(116.33,10.16) v4(116.46,98.81) v4(116.59,144.4) v4(116.59,142.62) v4(116.59,100.97) v4(116.71,134.24) v4(116.71,132.46) v4(116.71,122.68) v4(116.71,120.9) v4(116.84,151.26) v4(116.84,150.5) v4(116.84,149.73) v4(116.84,148.97) v4(116.84,148.21) v4(116.84,113.92) v4(116.84,112.14) v4(116.84,63.25) v4(117.22,109.86) v4(117.73,151.26) v4(117.73,150.5) v4(117.73,149.73) v4(117.73,148.97) v4(117.73,148.21) v4(117.86,117.6) v4(117.86,115.82) v4(117.86,102.23) v4(118.11,57.02) v4(118.74,126.75) v4(118.74,124.97) v4(118.74,116.71) v4(119.05,150.78) v4(119.05,148.8) v4(119.05,147.01) v4(119.05,145.21) v4(119.05,143.41) v4(119,56.01) v4(119,53.34) v4(119,51.69) v4(119.13,48.51) v4(119.41,141.08) v4(119.51,32.51) v4(119.51,27.31) v4(119.51,18.92) v4(119.51,15.11) v4(119.51,10.29) v4(119.63,125.86) v4(119.63,110.24) v4(119.63,21.59) v4(119.76,117.6) v4(119.76,115.82) v4(120.4,59.82) v4(120.65,126.75) v4(120.65,124.97) v4(120.65,96.52) v4(120.76,140.27) v4(120.9,113.92) v4(120.9,112.14) v4(121.28,98.04) v4(121.69,107.11) v4(121.83,150.87) v4(121.83,148.89) v4(121.83,147.1) v4(121.83,145.3) v4(121.83,143.5) v4(121.79,113.03) v4(121.79,109.86) v4(121.92,79.38) v4(122.05,50.29) v4(122.17,30.48) v4(122.17,28.7) v4(122.46,140.36) v4(122.43,105.03) v4(122.43,99.31) v4(122.69,137.67) v4(122.69,135.64) v4(122.69,131.95) v4(122.69,129.92) v4(122.69,127.38) v4(122.69,125.35) v4(122.81,113.92) v4(122.81,112.14) v4(123.06,151.26) v4(123.06,150.5) v4(123.06,149.73) v4(123.06,148.97) v4(123.06,148.21) v4(123.07,134.37) v4(123.07,133.35) v4(123.07,123.32) v4(123.07,121.28) v4(123.06,29.59) v4(123.19,146.43) v4(123.19,144.65) v4(123.32,106.43) v4(123.32,103.51) v4(123.32,98.55) v4(123.57,34.67) v4(123.85,139.49) v4(123.85,138.41) v4(123.95,151.26) v4(123.95,150.5) v4(123.95,149.73) v4(123.95,148.97) v4(123.95,148.21) v4(124.05,105.56) v4(124.08,145.54) v4(124.08,119) v4(124.08,86.36) v4(124.08,48.39) v4(124.08,30.48) v4(124.08,28.7) v4(124.21,129.16) v4(124.21,128.14) v4(124.21,117.35) v4(124.34,115.19) v4(124.46,110.49) v4(124.84,151.26) v4(124.84,150.5) v4(124.84,149.73) v4(124.84,148.97) v4(124.84,148.21) v4(124.97,6.48) v4(124.99,107.09) v4(125.1,146.43) v4(125.1,144.65) v4(125.2,105.61) v4(125.22,103.51) v4(125.61,113.28) v4(125.6,111.38) v4(125.6,75.95) v4(126.12,150.11) v4(126.12,148.34) v4(126.36,55.5) v4(126.36,50.17) v4(126.36,46.23) v4(127,149.23) v4(127,103.51) v4(127.58,107.21) v4(127.76,4.95) v4(128.02,150.11) v4(128.02,148.34) v4(128.27,79.38) v4(128.4,113.28) v4(128.45,105.56) v4(128.4,95.5) v4(128.52,110.49) v4(128.52,97.54) v4(128.91,80.9) v4(128.91,59.31) v4(128.91,56.64) v4(128.91,52.96) v4(128.91,47.62) v4(128.91,43.56) v4(128.91,33.4) v4(129.16,151.26) v4(129.16,150.5) v4(129.16,149.73) v4(129.16,148.97) v4(129.16,148.21) v4(129.16,146.43) v4(129.16,144.65) v4(129.67,115.19) v4(129.59,106.86) v4(129.62,105.59) v4(129.8,129.16) v4(129.8,128.14) v4(129.93,119) v4(129.93,117.35) v4(130.05,151.26) v4(130.05,150.5) v4(130.05,149.73) v4(130.05,148.97) v4(130.05,148.21) v4(130.05,145.54) v4(130.05,139.45) v4(130.05,138.43) v4(130.18,96.14) v4(130.3,112.65) v4(130.3,110.87) v4(130.63,107.44) v4(130.94,151.26) v4(130.94,150.5) v4(130.94,149.73) v4(130.94,148.97) v4(130.94,148.21) v4(130.94,134.37) v4(130.94,133.35) v4(130.94,123.32) v4(130.94,121.28) v4(131.07,146.43) v4(131.07,144.65) v4(131.19,111.76) v4(131.19,92.33) v4(131.19,79.76) v4(131.32,137.67) v4(131.32,135.64) v4(131.32,131.95) v4(131.32,129.92) v4(131.32,127.38) v4(131.32,125.35) v4(131.44,41.02) v4(131.54,140.36) v4(131.57,44.83) v4(131.83,103.76) v4(131.83,97.54) v4(131.95,94.36) v4(132.17,150.87) v4(132.17,148.89) v4(132.17,147.1) v4(132.17,145.3) v4(132.17,143.5) v4(132.21,112.65) v4(132.21,110.87) v4(132.97,6.1) v4(133.24,140.27) v4(133.22,116.33) v4(133.22,114.55) v4(133.6,96.27) v4(133.98,23.88) v4(134.11,115.44) v4(134.11,26.29) v4(134.24,79.76) v4(134.24,67.06) v4(134.24,59.82) v4(134.24,57.4) v4(134.24,54.48) v4(134.21,51.51) v4(134.24,47.5) v4(134.49,92.46) v4(134.59,141.08) v4(134.62,107.95) v4(134.75,105.16) v4(134.87,74.93) v4(134.87,21.84) v4(134.95,150.78) v4(134.95,148.8) v4(134.95,147.01) v4(134.95,145.21) v4(134.95,143.41) v4(135,100.84) v4(135,99.06) v4(135.13,116.33) v4(135.13,114.55) v4(135.51,23.62) v4(135.64,123.83) v4(135.64,122.05) v4(135.76,94.49) v4(135.76,88.77) v4(135.76,65.79) v4(135.89,90.3) v4(136.14,106.43) v4(136.27,151.26) v4(136.27,150.5) v4(136.27,149.73) v4(136.27,148.97) v4(136.27,148.21) v4(136.27,112.65) v4(136.27,110.87) v4(136.4,22.48) v4(136.53,122.94) v4(136.53,97.79) v4(136.65,146.56) v4(136.65,144.78) v4(136.65,102.74) v4(137.16,151.26) v4(137.16,150.5) v4(137.16,149.73) v4(137.16,148.97) v4(137.16,148.21) v4(137.16,133.6) v4(137.16,131.83) v4(137.16,111.76) v4(137.16,86.87) v4(137.16,84.33) v4(137.16,79.76) v4(137.11,48.59) v4(137.29,64.39) v4(137.29,26.42) v4(137.29,21.72) v4(137.41,58.93) v4(137.41,57.28) v4(137.41,53.85) v4(137.41,50.55) v4(137.54,145.67) v4(137.54,123.83) v4(137.54,122.05) v4(137.54,107.82) v4(137.54,92.58) v4(137.67,65.79) v4(138.05,151.26) v4(138.05,150.5) v4(138.05,149.73) v4(138.05,148.97) v4(138.05,148.21) v4(138.05,132.72) v4(138.05,67.06) v4(138.18,112.65) v4(138.18,110.87) v4(138.18,43.82) v4(138.15,38.81) v4(138.3,104.52) v4(138.28,33.99) v4(138.43,137.67) v4(138.43,135.89) v4(138.56,146.56) v4(138.56,144.78) v4(138.56,127.51) v4(138.56,125.73) v4(138.56,100.97) v4(138.56,7.49) v4(138.68,99.06) v4(138.94,95.12) v4(138.94,53.47) v4(138.94,51.69) v4(138.94,48.13) v4(138.94,26.54) v4(139.06,133.6) v4(139.06,131.83) v4(139.32,136.78) v4(139.45,126.62) v4(139.57,150.24) v4(139.57,148.46) v4(139.57,45.92) v4(139.57,31.5) v4(139.7,63.75) v4(139.7,61.98) v4(139.83,102.87) v4(139.83,89.28) v4(139.83,65.66) v4(139.83,52.58) v4(139.83,47.24) v4(139.83,29.08) v4(139.95,67.06) v4(139.95,37.08) v4(140.02,111.75) v4(140.08,106.3) v4(140.21,92.33) v4(140.21,71.88) v4(140.33,137.67) v4(140.33,135.89) v4(140.46,149.35) v4(140.46,127.51) v4(140.46,125.73) v4(140.59,62.87) v4(140.84,53.47) v4(140.84,51.69) v4(140.84,48.13) v4(140.84,46.36) v4(141.1,97.16) v4(141.1,22.86) v4(141.35,141.35) v4(141.35,139.57) v4(141.46,113.36) v4(141.48,150.24) v4(141.48,148.46) v4(141.55,107.53) v4(141.48,42.93) v4(141.48,41.15) v4(141.6,123.83) v4(141.6,122.05) v4(141.6,73.66) v4(141.6,63.75) v4(141.6,61.98) v4(141.73,65.66) v4(142.11,79.76) v4(142.24,140.46) v4(142.24,104.27) v4(142.24,21.72) v4(142.37,67.06) v4(142.37,42.04) v4(142.37,31.75) v4(142.37,29.97) v4(142.49,122.94) v4(142.54,114.62) v4(142.62,146.56) v4(142.62,144.78) v4(142.75,100.84) v4(143,98.93) v4(143,28.45) v4(143.13,59.94) v4(143.26,141.35) v4(143.26,139.57) v4(143.26,38.74) v4(143.26,30.86) v4(143.44,116.96) v4(143.38,42.93) v4(143.38,41.15) v4(143.38,25.15) v4(143.51,145.67) v4(143.51,123.83) v4(143.51,122.05) v4(143.51,65.91) v4(143.51,62.87) v4(143.51,52.83) v4(143.64,45.47) v4(143.76,33.66) v4(143.79,107.98) v4(143.89,72.26) v4(144.02,105.79) v4(144.27,102.62) v4(144.27,31.75) v4(144.27,29.97) v4(144.4,137.67) v4(144.4,135.89) v4(144.4,92.58) v4(144.53,146.56) v4(144.53,144.78) v4(144.65,87.38) v4(144.87,118.39) v4(144.78,90.93) v4(144.78,89.28) v4(145.03,97.16) v4(145.29,136.78) v4(145.67,50.55) v4(145.8,36.2) v4(146.04,120.1) v4(146.05,72.9) v4(146.05,44.96) v4(146.18,66.42) v4(146.18,64.01) v4(146.18,58.93) v4(146.18,41.02) v4(146.3,137.67) v4(146.3,135.89) v4(146.3,132.21) v4(146.3,130.43) v4(146.3,100.97) v4(146.3,99.06) v4(146.67,110.49) v4(146.81,25.02) v4(146.81,21.97) v4(146.94,95.5) v4(146.94,24) v4(147.07,108.97) v4(147.19,131.32) v4(147.19,105.79) v4(147.19,103.25) v4(147.48,121.54) v4(147.95,79.88) v4(148.08,99.95) v4(148.08,29.97) v4(148.21,132.21) v4(148.21,130.43) v4(148.21,74.04) v4(148.21,33.66) v4(148.59,84.07) v4(148.84,100.71) v4(148.97,138.68) v4(148.97,136.91) v4(148.97,97.66) v4(149,111.39) v4(149.09,121) v4(149.1,102.62) v4(149.27,123.33) v4(149.22,107.44) v4(149.22,105.66) v4(149.22,62.99) v4(149.35,65.28) v4(149.86,137.8) v4(149.81,121.71) v4(150.11,106.55) v4(150.24,91.82) v4(150.24,76.07) v4(150.24,52.96) v4(150.44,112.82) v4(150.71,124.77) v4(150.88,138.68) v4(150.88,136.91) v4(150.88,36.7) v4(151,31.12) v4(151.13,107.44) v4(151.13,105.66) v4(151.38,109.09) v4(151.64,87.12) v4(151.89,142.37) v4(151.89,140.59) v4(151.97,125.49) v4(152.02,95.12) v4(152.15,113.99) v4(152.15,111.12) v4(152.4,77.72) v4(152.4,40.77) v4(152.4,38.99) v4(152.68,126.2) v4(152.78,141.48) v4(153.04,117.05) v4(153.03,110.24) v4(153.03,49.78) v4(153.03,33.66) v4(153.16,104.52) v4(153.31,127.37) v4(153.29,39.88) v4(153.58,115.43) v4(153.76,117.76) v4(153.8,142.37) v4(153.8,140.59) v4(153.92,57.28) v4(154.05,111.12) v4(154.18,59.31) v4(154.31,40.77) v4(154.31,38.99) v4(154.75,128.81) v4(154.81,133.48) v4(154.81,32.13) v4(154.81,30.35) v4(154.94,138.68) v4(154.94,136.91) v4(155.19,131.95) v4(155.19,107.44) v4(155.19,105.66) v4(155.19,79.12) v4(155.19,78.42) v4(155.19,77.72) v4(155.19,77.02) v4(155.19,76.32) v4(155.38,117.22) v4(155.45,59.69) v4(155.57,25.02) v4(155.7,31.24) v4(155.83,137.8) v4(155.83,21.21) v4(155.89,79.12) v4(155.89,78.42) v4(155.89,77.72) v4(155.89,77.02) v4(155.89,76.32) v4(156.12,128.45) v4(156.08,106.55) v4(156.08,46.48) v4(156.21,135.38) v4(156.34,57.28) v4(156.46,130.81) v4(156.59,79.12) v4(156.59,78.42) v4(156.59,77.02) v4(156.59,76.32) v4(156.72,32.13) v4(156.72,30.35) v4(156.84,138.68) v4(156.84,136.91) v4(156.82,118.66) v4(156.88,129.21) v4(157.1,107.44) v4(157.1,105.66) v4(157.29,79.12) v4(157.29,78.42) v4(157.29,77.72) v4(157.29,77.02) v4(157.29,76.32) v4(157.44,140.97) v4(157.48,136.65) v4(157.53,119.92) v4(157.48,61.98) v4(157.98,141.51) v4(158.07,140.34) v4(157.99,79.12) v4(157.99,78.42) v4(157.99,77.72) v4(157.99,77.02) v4(157.99,76.32) v4(158.24,133.48) v4(158.25,120.64) v4(158.37,31.75) v4(158.52,142.05) v4(158.61,140.88) v4(158.62,30.1) v4(158.7,139.71) v4(158.75,137.92) v4(158.75,22.48) v4(158.88,33.66) v4(159.06,142.59) v4(159.15,141.42) v4(159.24,140.25) v4(159.42,121.27) v4(159.51,134.75) v4(159.59,143.13) v4(159.68,141.96) v4(159.77,140.79) v4(159.89,57.28) v4(160.02,139.19) v4(160.05,133.39) v4(160.22,142.5) v4(160.31,141.33) v4(160.52,124.07) v4(160.66,72.39) v4(160.66,70.61) v4(160.85,141.87) v4(160.78,136.02) v4(160.86,122.7) v4(160.91,54.86) v4(160.91,53.09) v4(161.24,124.79) v4(161.31,134.65) v4(161.31,133.39) v4(161.29,113.03) v4(161.29,111.25) v4(161.42,140.59) v4(161.4,132.04) v4(161.54,71.5) v4(161.54,29.97) v4(161.8,53.98) v4(162.05,137.29) v4(162.18,112.14) v4(162.31,33.66) v4(162.47,135.94) v4(162.43,31.75) v4(162.56,72.39) v4(162.56,70.61) v4(162.65,133.3) v4(162.69,26.67) v4(162.81,54.86) v4(162.81,53.09) v4(162.94,124.46) v4(163.01,136.48) v4(163.1,135.31) v4(163.19,113.03) v4(163.19,111.25) v4(163.19,50.55) v4(163.19,48.77) v4(163.45,138.68) v4(163.55,137.02) v4(163.64,135.85) v4(163.73,134.69) v4(164.08,137.56) v4(164.17,136.39) v4(164.08,123.19) v4(164.08,49.66) v4(164.26,135.22) v4(164.27,129.17) v4(164.21,116.71) v4(164.21,114.94) v4(164.34,107.7) v4(164.34,105.92) v4(164.62,138.1) v4(164.71,136.93) v4(164.72,133.93) v4(164.8,135.76) v4(165.1,115.82) v4(165.1,50.55) v4(165.1,48.77) v4(165.25,137.47) v4(165.23,106.81) v4(165.34,136.3) v4(165.53,130.43) v4(165.53,129.17) v4(165.62,127.82) v4(165.61,126.24) v4(165.61,122.81) v4(165.88,136.84) v4(165.98,135.19) v4(165.98,133.93) v4(166.07,132.58) v4(166.12,116.71) v4(166.12,114.94) v4(166.24,107.7) v4(166.24,105.92) v4(166.78,131.63) v4(166.87,129.08) v4(166.88,127.51) v4(167.26,113.03) v4(167.26,111.25) v4(167.32,133.84) v4(167.32,132.17) v4(167.41,131) v4(167.51,124.21) v4(167.86,132.71) v4(167.95,131.54) v4(168.04,130.38) v4(168.15,128.78) v4(168.15,112.14) v4(168.4,133.25) v4(168.49,132.08) v4(168.58,130.91) v4(168.78,125.48) v4(168.93,133.79) v4(169.02,132.62) v4(169.11,131.45) v4(169.16,113.03) v4(169.16,111.25) v4(169.42,130.05) v4(169.56,133.16) v4(169.65,131.99) v4(169.67,41.53) v4(169.67,39.75) v4(170.05,126.75) v4(170.19,132.53) v4(170.56,40.64) v4(170.81,131.44) v4(170.81,52.2) v4(170.81,48.51) v4(171.2,119.51) v4(171.2,117.73) v4(171.32,128.02) v4(171.45,105.28) v4(171.45,103.51) v4(171.58,41.53) v4(171.58,39.75) v4(171.81,126.6) v4(172.08,118.62) v4(172.35,127.14) v4(172.34,104.39) v4(172.44,125.97) v4(172.72,129.41) v4(172.89,127.68) v4(172.98,126.51) v4(173.07,125.35) v4(173.1,119.51) v4(173.1,117.73) v4(173.35,105.28) v4(173.35,103.51) v4(173.35,30.61) v4(173.35,28.83) v4(173.42,128.22) v4(173.51,127.05) v4(173.6,125.88) v4(173.96,128.76) v4(174.05,127.59) v4(173.99,97.41) v4(173.99,96.71) v4(173.99,95.31) v4(173.99,94.61) v4(174.14,126.42) v4(174.12,123.19) v4(174.12,121.41) v4(174.11,82.81) v4(174.11,82.11) v4(174.11,80.71) v4(174.11,80.01) v4(174.24,29.72) v4(174.59,128.13) v4(174.68,126.96) v4(174.69,97.41) v4(174.69,94.61) v4(174.81,82.81) v4(174.81,80.71) v4(174.81,80.01) v4(175.01,122.3) v4(175.22,127.5) v4(175.26,30.61) v4(175.26,28.83) v4(175.39,114.68) v4(175.39,112.9) v4(175.39,97.41) v4(175.39,96.71) v4(175.39,96.01) v4(175.39,95.31) v4(175.39,94.61) v4(175.51,82.81) v4(175.51,82.11) v4(175.51,80.71) v4(175.51,80.01) v4(176.02,123.19) v4(176.02,121.41) v4(176.09,97.41) v4(176.28,113.79) v4(176.21,82.81) v4(176.79,97.41) v4(176.79,96.71) v4(176.79,95.31) v4(176.79,94.61) v4(176.91,82.81) v4(176.91,82.11) v4(176.91,80.71) v4(176.91,80.01) v4(177.04,106.3) v4(177.04,104.52) v4(177.16,119.51) v4(177.16,117.73) v4(177.29,114.68) v4(177.29,112.9) v4(177.93,105.41) v4(178.05,118.62) v4(178.94,106.3) v4(178.94,104.52) v4(179.07,119.51) v4(179.07,117.73) v5(38.73,69.22) v5(45.72,63.63) v5(50.42,68.58) v5(55.8,62.49) v5(55.8,60.49) v5(55.8,54.62) v5(55.8,52.62) v5(55.88,68.33) v5(56.7,63.59) v5(56.7,59.39) v5(56.7,55.72) v5(56.7,51.52) v5(58.9,63.69) v5(58.9,59.29) v5(58.9,55.82) v5(58.9,51.42) v5(60.1,63.39) v5(60.1,59.59) v5(60.1,55.52) v5(60.1,51.72) v5(60.33,66.29) v5(61.94,44.98) v5(62.03,42.78) v5(62.24,46.18) v5(63.14,41.88) v5(64.13,63.37) v5(65.13,41.88) v5(66.03,46.18) v5(66.24,42.78) v5(66.33,44.98) v5(69.21,65.15) v5(70.27,44.98) v5(70.37,42.78) v5(70.57,46.18) v5(71.47,41.88) v5(73.47,41.88) v5(74.37,46.18) v5(74.57,42.78) v5(74.67,44.98) v5(75.69,63.75) v5(75.78,83.41) v5(75.88,81.21) v5(76.08,84.61) v5(76.98,80.31) v5(78.98,80.31) v5(79.88,84.61) v5(80.08,81.21) v5(80.18,83.41) v5(85.94,83.41) v5(86.04,81.21) v5(86.24,84.61) v5(87.14,80.31) v5(88.22,75.28) v5(88.32,73.08) v5(88.52,76.48) v5(89.14,80.31) v5(89.42,72.18) v5(90.04,84.61) v5(90.24,81.21) v5(90.34,83.41) v5(91.42,72.18) v5(92.32,76.48) v5(92.52,73.08) v5(92.62,75.28) v5(98.38,75.28) v5(98.48,73.08) v5(98.68,76.48) v5(99.58,72.18) v5(101.58,72.18) v5(102.48,76.48) v5(102.68,73.08) v5(102.78,75.28) v5(103.48,66.65) v5(103.48,62.85) v5(104.68,66.95) v5(104.68,62.55) v5(106.88,66.85) v5(106.88,62.65) v5(107.78,65.75) v5(107.78,63.75)
